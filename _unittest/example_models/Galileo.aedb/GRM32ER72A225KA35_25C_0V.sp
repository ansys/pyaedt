*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3225M(1210)/X7R/2.2uF/100V
* Murata P/N :GRM32ER72A225KA35
* Property : C = 2.2[uF]
* Data Generated on Mar 14, 2018
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100Hz-6GHz
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM32ER72A225KA35_25C_0V port1 port2
C1 port1 11 2.18e-6
L2 11 12 1.28e-10
R3 12 13 2.50e-3
C4 13 14 8.43e-5
R4 13 14 91.0
C5 14 15 3.62e-4
R5 14 15 1.44
C6 15 16 2.76e-4
R6 15 16 1.91e-1
C7 16 17 2.39e-4
R7 16 17 2.22e-2
C8 17 18 1.82e-4
R8 17 18 2.69e-3
L9 18 19 3.18e-10
R9 18 19 3.02e-2
L10 19 20 1.76e-11
R10 19 20 2.18e-2
C11 20 21 4.33e-6
L11 20 21 1.35e-10
R11 20 21 3.50e-2
C12 21 22 2.64e-6
L12 21 22 7.74e-11
R12 21 22 1.86e-2
C13 22 port2 1.81e-12
L13 22 port2 2.74e-10
R13 22 port2 46.5
R100 port1 11 2.27e+8
.ENDS GRM32ER72A225KA35_25C_0V
