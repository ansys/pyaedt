$begin 'AnsoftProject'
	Created='Fri Sep 17 15:39:56 2021'
	Product='ElectronicsDesktop'
	FileOwnedByWorkbench=false
	$begin 'Desktop'
		Version(2024, 1)
		InfrastructureVersion(1, 0)
		$begin 'Documentation'
			Document='$PROJECTDIR/Tutorial 4.pdf'
		$end 'Documentation'
		$begin 'FactoryHeader'
			$begin 'geometry3deditor'
				KernelVersion(2, 0)
				ProjectContainsGeometry3D='0'
			$end 'geometry3deditor'
		$end 'FactoryHeader'
	$end 'Desktop'
	UsesAdvancedFeatures=false
	NextUniqueID=0
	MoveBackwards=false
	$begin 'HFSSEnvironment'
		Version(1, 0)
	$end 'HFSSEnvironment'
	$begin 'PlanarEMEnvironment'
		Version(1, 0)
	$end 'PlanarEMEnvironment'
	$begin 'Q3DEnvironment'
		Version(1, 0)
	$end 'Q3DEnvironment'
	$begin '2DExtractorEnvironment'
		Version(1, 0)
	$end '2DExtractorEnvironment'
	$begin 'NexximEnvironment'
		Version(1, 0)
	$end 'NexximEnvironment'
	$begin 'NexximNetlistEnvironment'
		Version(1, 0)
	$end 'NexximNetlistEnvironment'
	$begin 'EmitEnvironment'
		Version(1, 0)
	$end 'EmitEnvironment'
	$begin 'Maxwell3DEnvironment'
		Version(1, 0)
	$end 'Maxwell3DEnvironment'
	$begin 'Maxwell2DEnvironment'
		Version(1, 0)
	$end 'Maxwell2DEnvironment'
	$begin 'RMxprtEnvironment'
		Version(1, 0)
	$end 'RMxprtEnvironment'
	$begin 'MaxCirEnvironment'
		Version(1, 0)
	$end 'MaxCirEnvironment'
	$begin 'SimplorerEnvironment'
		Version(1, 0)
	$end 'SimplorerEnvironment'
	$begin 'IcepakEnvironment'
		Version(1, 0)
	$end 'IcepakEnvironment'
	$begin 'MechanicalEnvironment'
		Version(1, 0)
	$end 'MechanicalEnvironment'
	$begin 'SchematicEnvironment'
		Version(1, 0)
	$end 'SchematicEnvironment'
	$begin 'geometry3deditor'
		Version(1, 0)
	$end 'geometry3deditor'
	ReadVersion=11
	$begin 'DesignMgrEnvironment'
		CompInstCounter=6
		GPortCounter=0
		NetCounter=0
		Alias('Ieee;Simplorer Elements\\Ieee', 'Std;Simplorer Elements\\Std', 'Basic_VHDLAMS;Simplorer Elements\\Basic Elements VHDLAMS\\Basic Elements VHDLAMS', 'Digital_Elements;Simplorer Elements\\Digital Elements\\Digital Elements', 'Transformations;Simplorer Elements\\Tools\\Transformations\\Transformations', 'HEV_VHDLAMS;Simplorer Elements\\HEV VHDLAMS\\HEV VHDLAMS', 'automotive_vda;Simplorer Elements\\VDALibs VHDLAMS\\automotive_vda', 'example_boardnet;Simplorer Elements\\VDALibs VHDLAMS\\example_boardnet', 'example_ecar;Simplorer Elements\\VDALibs VHDLAMS\\example_ecar', 'fundamentals_vda;Simplorer Elements\\VDALibs VHDLAMS\\fundamentals_vda', 'hybrid_emc_vda;Simplorer Elements\\VDALibs VHDLAMS\\hybrid_emc_vda', 'megma;Simplorer Elements\\VDALibs VHDLAMS\\megma', 'modelica_rotational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_rotational', 'modelica_thermal;Simplorer Elements\\VDALibs VHDLAMS\\modelica_thermal', 'modelica_translational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_translational', 'spice2vhd;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd', 'spice2vhd_devices;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd_devices', 'aircraft_electrical_vhdlams;Simplorer Elements\\Aircraft Electrical VHDLAMS\\Aircraft Electrical VHDLAMS', 'power_system_vhdlams;Simplorer Elements\\Power System VHDLAMS\\Power System VHDLAMS')
	$end 'DesignMgrEnvironment'
	$begin 'ProjectDatasets'
		NextUniqueID=0
		MoveBackwards=false
		DatasetType='ProjectDatasetType'
		$begin 'DatasetDefinitions'
		$end 'DatasetDefinitions'
	$end 'ProjectDatasets'
	VariableOrders[0:]
	$begin 'Definitions'
		$begin 'Materials'
			$begin 'vacuum'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=230
						Green=230
						Blue=230
						Transparency=0.949999988079071
					$end 'MatAppearanceData'
				$end 'AttachedData'
				permittivity='1'
				ModTime=1499970477
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'vacuum'
		$end 'Materials'
		$begin 'SurfaceMaterials'
		$end 'SurfaceMaterials'
		$begin 'Scripts'
		$end 'Scripts'
		$begin 'Symbols'
			$begin 'EMIT Design1'
				ModTime=1631884207
				CE=3
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0.00254, 0.00254, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, 0.000423333333333333, 0.00254, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'EMIT Design1'
			$begin 'antenna_emit'
				ModTime=1506373418
				CE=3
				Library='EMIT Elements\\Antennas'
				ModSinceLib=false
				LibLocation='SysLibrary'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('in', -0.00508, -0.00508, 0, 'N', 0, 0, false, 0, true, '', false, false, 'in', true)
				$end 'PinDef'
				$begin 'Graphics'
					Line(0, 1, 12566272, -0.00508, -0.00508, -8.67361737988404e-19, -0.00508, 0, 0, End=0, Join=0, LineStyle=0, BeginObj=0, EndObj=0)
					$begin '1'
						Polygon(0, 0, 12566272, -0.00254, 0, 0.00254, 0, 0, -0.004826, -0.001016, -0.002794, BorderCol=12566272, End=512, Join=8192)
					$end '1'
				$end 'Graphics'
				$begin 'PropDisplayMap'
					Name(2, 5, 1, Text(1.01524691431543e-15, -0.0058808055555679, 0, 3, 5, false, 'Arial', 0, '[Name]', false, false, ExtentRect(0, 0, 0, 0, 1.01524691431543e-15, -0.0067560751207853, 0.0110138086956522, 0.00175053913043478, 0, 0, 0)))
				$end 'PropDisplayMap'
			$end 'antenna_emit'
			$begin 'antenna_passband_emit'
				ModTime=1627076133
				CE=3
				Library='EMIT Elements\\Antennas'
				ModSinceLib=false
				LibLocation='SysLibrary'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('in', -0.00508, -0.00508, 0, 'N', 0, 0, false, 0, true, '', false, false, 'in', true)
				$end 'PinDef'
				$begin 'Graphics'
					Line(0, 1, 12566272, -0.00508, -0.00508, -8.67361737988404e-19, -0.00508, 0, 0, End=0, Join=0, LineStyle=0, BeginObj=0, EndObj=0)
					$begin '1'
						Polygon(0, 0, 12566272, -0.00254, 0, 0.00254, 0, 0, -0.004826, -0.001016, -0.002794, BorderCol=12566272, End=512, Join=8192)
						Rect(0, 1, 16777215, 0, 0.001778, -0.001778, 0.00127, 0.00127, 12566272, 0, 8192)
						Text(0.001778, -0.002032, 0, 4, 3, false, 'Arial', 12566272, 'P', false, false, ExtentRect(0, 0, 12566272, 0, 0.001778, -0.00175195770586642, 0.000700105735333939, 0.0011201691765343, 12566272, 0, 0))
					$end '1'
				$end 'Graphics'
				$begin 'PropDisplayMap'
					Name(2, 5, 1, Text(1.01524691431543e-15, -0.0058808055555679, 0, 3, 5, false, 'Arial', 0, '[Name]', false, false, ExtentRect(0, 0, 0, 0, 1.01524691431543e-15, -0.00675404513223728, 0.00508829984097733, 0.00174647915333875, 0, 0, 0)))
				$end 'PropDisplayMap'
			$end 'antenna_passband_emit'
		$end 'Symbols'
		$begin 'DefInfo'
			'EMIT Design1'(1001, 3, 0, 0, '', 1631884207, '', 'EMIT Design1', '', '', '', '', '', 'Design.bmp', '', 'Project', '', '', 1631884207, '', 0)
			Antenna(1001, 3, 0, 1, '', 1506114676, '', 'EMIT Elements\\Antennas:antenna_emit', '', '', '', 'Antenna', 'EMITAntennas.htm', 'antenna.bmp', 'EMIT Elements\\Antennas', 'SysLibrary', '', '', 1487712789, '', 0)
		$end 'DefInfo'
		$begin 'Compdefs'
			$begin 'EMIT Design1'
				Library=''
				CircuitEnv=3
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				$begin 'Properties'
					TextProp('Representation', 'SRD', '', 'EMIT Design1')
					TextProp('Owner', 'SRD', '', 'EMIT')
				$end 'Properties'
				CompExtID=6
			$end 'EMIT Design1'
			$begin 'Antenna'
				Library='EMIT Elements\\Antennas'
				CircuitEnv=3
				Refbase='Antenna'
				NumParts=1
				ModSinceLib=false
				Terminal('in', '', 'A', false, 0, 1, '', 'Electrical', '0')
				CompExtID=7
				$begin 'Parameters'
					ButtonProp('Model', 'D', '', 'Configure...', '<Project>', 38050, ButtonPropClientData())
					TextProp('EMIT_Key_Type', 'HD', '', 'AntennaNode')
					TextProp('PrettyType', 'HD', '', 'Antenna')
					VariableProp('Antenna Noise Temperature', 'HD', 'The antenna noise temperature (deg Kelvin)', '290kel')
				$end 'Parameters'
				$begin 'EmitCompExtension'
					$begin 'node'
						fullname='NODE-*-Scene-*-Antenna'
						$begin 'properties'
							AdjustSourceHeight='false'
							AntennaPol='Vertical'
							AntennaSidePorts=''
							AntennaTemperature='290.0'
							AntennaType='FFPatTable'
							AutoAdjustSrcOrientation='true'
							AutoAdjustmentType='None'
							AutoScaled='true'
							BacklobeDBDown='15'
							BeamAxis='XAxis'
							ClearDisplayList='true'
							ClearDisplayList1='true'
							ClearDisplayList2='true'
							ClearDisplayList3='true'
							Color='#8064A2'
							CrossDipoleMode='Freestanding'
							CrossDipolePol='RHCP'
							DuplicateElement='false'
							Filename=''
							FirstSidelobeDBDown='10'
							FirstSidelobeHorBW='10'
							FirstSidelobeVertBW='30'
							FlareAngle='20'
							FreqList=''
							Has1stSidelobe='false'
							HeightFlareAngle='35'
							HelpUrl='com.delcross.emit/doc/02 - User Guide/03 - Project Tree/01 - Scene/02 - Antenna/Antenna.htm'
							Highlighted='true'
							HorBW='60'
							HornDiameter='0.3'
							HornHeight='0.5'
							HornWidth='0.3'
							IconAlias=':Antenna'
							Info_AzSample=''
							Info_ElSample=''
							Info_FreqDom=''
							Info_HasFreqDom=''
							Info_NumElectric=''
							Info_NumImagedElec=''
							Info_NumImagedMag=''
							Info_NumMagnetic=''
							Info_RenormFlag=''
							Info_TE10CutoffFreq=''
							Info_TE11CutoffFreq=''
							Info_WaveguideHeight=''
							LinkChildParameters='true'
							Name='Antenna'
							Notes=''
							NumberOfPorts='2'
							OffsetHeight='.1'
							Orientation='0.0 0.0 0.0'
							OrientationMode='rpyDeg'
							OverrideOffset='false'
							Parent='NODE-*-Scene'
							PeakGainDBi='0'
							PickPositionGbl=''
							Position='0.0 0.0 0.0'
							PositionDefined='false'
							RadioSidePorts='in'
							ReferencePlane='XY Plane'
							RelativeOrientation='0.0 0.0 0.0'
							RelativePosition='0.0 0.0 0.0'
							ResonantFrequency='300e6'
							Selected='true'
							ShowAxes='true'
							ShowIcon='true'
							ShowRelativeCoords='false'
							SizeScaler='0.1'
							SlotLength='0.1'
							SrcPosOffset='0.0 0.0 0.0'
							SubType='Isotropic'
							SweCustonNMode='50'
							SweNModeTruncation='Dynamic'
							Tags=''
							Type='AntennaNode'
							UseAntennaPattern='false'
							VSWR='1.0'
							VertBW='30'
							Visible='false'
							WaveguideWidth='0.15'
							WidthFlareAngle='20'
							WireLength='0.1'
						$end 'properties'
					$end 'node'
				$end 'EmitCompExtension'
			$end 'Antenna'
		$end 'Compdefs'
	$end 'Definitions'
	DesignIDServer=4
	MoveBackwards=false
	$begin 'EMIT Design'
		CirEnv=3
		Revision=4
		RepRewriteV2=true
		Name='EMIT Design1'
		DesignID=0
		$begin 'Circuit'
			ComponentName='EMIT Design1'
			AutoFP=''
			$begin 'DesignDatasets'
				NextUniqueID=0
				MoveBackwards=false
				DatasetType='DesignDatasetType'
				$begin 'DatasetDefinitions'
				$end 'DatasetDefinitions'
			$end 'DesignDatasets'
			VariableOrders[0:]
			$begin 'Compinst'
				ID='2'
				Status='Status'
				CompName='EMIT Elements\\Antennas:Antenna'
				Symbol='EMIT Elements\\Antennas:antenna_passband_emit'
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '2')
				$end 'Properties'
				$begin 'Parameters'
					ButtonProp('Model', 'OD', '', 'Configure...', '<Project>', 38050, ButtonPropClientData())
					TextProp('Name', 'ID', '', 'GPS')
				$end 'Parameters'
				$begin 'EmitCompInstanceExtension'
					$begin 'node'
						fullname='NODE-*-Scene-*-GPS'
						$begin 'properties'
							AdjustSourceHeight='false'
							AntennaTemperature='290.0'
							AntennaType='FFPatTable'
							AutoAdjustSrcOrientation='true'
							AutoAdjustmentType='None'
							AutoScaled='true'
							ClearDisplayList1='true'
							ClearDisplayList2='true'
							ClearDisplayList3='true'
							Color='#8064A2'
							LinkChildParameters='true'
							Name='GPS'
							NodeOrder='0'
							NumberOfPorts='2'
							Orientation='0.0 0.0 0.0'
							OrientationMode='rpyDeg'
							Parent='NODE-*-Scene'
							PeakGainDBi='30.000000000000000000'
							Position='5.099999999999999645 0.000000000000000000 0.200000000000000011'
							PositionDefined='true'
							RadioSidePorts='in'
							ReferencePlane='XY Plane'
							RelativeOrientation='0.0 0.0 0.0'
							RelativePosition='0.0 0.0 0.0'
							ShowAxes='true'
							ShowIcon='false'
							ShowRelativeCoords='false'
							SizeScaler='0.1'
							SrcPosOffset='0.0 0.0 0.0'
							SubType='Hemitropic'
							SweCustonNMode='50'
							SweNModeTruncation='Dynamic'
							Type='AntennaNode'
							UseAntennaPattern='false'
							VSWR='2.000000000000000000'
							Visible='true'
						$end 'properties'
					$end 'node'
					$begin 'node'
						fullname='NODE-*-Scene-*-GPS-*-L1 Passband'
						$begin 'properties'
							AntennaHigherCutoffFrequency='1585500000.000000000000000000'
							AntennaHigherStopBandFrequency='1586000000.000000000000000000'
							AntennaLowerCutoffFrequency='1565500000.000000000000000000'
							AntennaLowerStopBandFrequency='1565000000.000000000000000000'
							Enabled='true'
							Name='L1 Passband'
							NodeOrder='1'
							NumberOfPorts='2'
							OutbandLoss='30.000000000000000000'
							Parent='NODE-*-Scene-*-GPS'
							PassbandLoss='0'
							Type='AntennaPassband'
						$end 'properties'
					$end 'node'
					$begin 'node'
						fullname='NODE-*-Scene-*-GPS-*-L2 Passband'
						$begin 'properties'
							AntennaHigherCutoffFrequency='1237600000.000000000000000000'
							AntennaHigherStopBandFrequency='1238100000.000000000000000000'
							AntennaLowerCutoffFrequency='1217600000.000000000000000000'
							AntennaLowerStopBandFrequency='1217100000.000000000000000000'
							Enabled='true'
							Name='L2 Passband'
							NodeOrder='2'
							NumberOfPorts='2'
							OutbandLoss='30.000000000000000000'
							Parent='NODE-*-Scene-*-GPS'
							PassbandLoss='0'
							Type='AntennaPassband'
						$end 'properties'
					$end 'node'
					$begin 'node'
						fullname='NODE-*-Scene-*-GPS-*-Pattern'
						$begin 'properties'
							AutoScaled='true'
							AxisLabelFont='Sans Serif,12,-1,5,75,0,0,0,0,0'
							AxisTickLabelFont='Sans Serif,10,-1,5,50,0,0,0,0,0'
							ColorByField='true'
							ColorMapClipped='false'
							ColorMapLabel='Normalized Field Density [Linear]'
							ColorMapMax='1'
							ColorMapMax_Locked='false'
							ColorMapMin='0'
							ColorMapMin_Locked='false'
							ColorMapReversed='false'
							ColorMapType='[Spectrum]'
							DBCutoff='-30'
							FillColor='#8064A2'
							Name='Pattern'
							NodeOrder='0'
							Orientation='0 0 0'
							Parent='NODE-*-Scene-*-GPS'
							PolType='Composite'
							Position='0 0 0'
							RadPatRenderMode='Flat-shaded'
							ScaleType='Linear'
							SizeScaler='0.019498000000000001'
							Type='RadPatNode'
							Visible='true'
							WireColor='#8064A2'
						$end 'properties'
					$end 'node'
				$end 'EmitCompInstanceExtension'
			$end 'Compinst'
			$begin 'Compinst'
				ID='3'
				Status='Status'
				CompName='EMIT Elements\\Antennas:Antenna'
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '3')
				$end 'Properties'
				$begin 'Parameters'
					ButtonProp('Model', 'OD', '', 'Configure...', '<Project>', 38050, ButtonPropClientData())
					TextProp('Name', 'ID', '', 'UHF-1')
				$end 'Parameters'
				$begin 'EmitCompInstanceExtension'
					$begin 'node'
						fullname='NODE-*-Scene-*-UHF-1'
						$begin 'properties'
							AdjustSourceHeight='false'
							AntennaTemperature='290.0'
							AntennaType='FFPatTable'
							AutoAdjustSrcOrientation='true'
							AutoAdjustmentType='None'
							AutoScaled='true'
							ClearDisplayList1='true'
							ClearDisplayList2='true'
							ClearDisplayList3='true'
							Color='#8064A2'
							LinkChildParameters='true'
							Name='UHF-1'
							NodeOrder='1'
							NumberOfPorts='2'
							Orientation='0.0 0.0 0.0'
							OrientationMode='rpyDeg'
							Parent='NODE-*-Scene'
							PeakGainDBi='0'
							Position='1.199999999999999956 0.000000000000000000 0.400000000000000022'
							PositionDefined='true'
							RadioSidePorts='in'
							ReferencePlane='XY Plane'
							RelativeOrientation='0.0 0.0 0.0'
							RelativePosition='0.0 0.0 0.0'
							ShowAxes='true'
							ShowIcon='false'
							ShowRelativeCoords='false'
							SizeScaler='0.1'
							SrcPosOffset='0.0 0.0 0.0'
							SubType='Isotropic'
							SweCustonNMode='50'
							SweNModeTruncation='Dynamic'
							Type='AntennaNode'
							UseAntennaPattern='false'
							VSWR='1.0'
							Visible='true'
						$end 'properties'
					$end 'node'
					$begin 'node'
						fullname='NODE-*-Scene-*-UHF-1-*-Pattern'
						$begin 'properties'
							AutoScaled='true'
							AxisLabelFont='Sans Serif,12,-1,5,75,0,0,0,0,0'
							AxisTickLabelFont='Sans Serif,10,-1,5,50,0,0,0,0,0'
							ColorByField='true'
							ColorMapClipped='false'
							ColorMapLabel='Normalized Field Density [Linear]'
							ColorMapMax='1'
							ColorMapMax_Locked='false'
							ColorMapMin='0'
							ColorMapMin_Locked='false'
							ColorMapReversed='false'
							ColorMapType='[Spectrum]'
							DBCutoff='-30'
							FillColor='#8064A2'
							Name='Pattern'
							NodeOrder='0'
							Orientation='0 0 0'
							Parent='NODE-*-Scene-*-UHF-1'
							PolType='Composite'
							Position='0 0 0'
							RadPatRenderMode='Flat-shaded'
							ScaleType='Linear'
							SizeScaler='0.019498000000000001'
							Type='RadPatNode'
							Visible='true'
							WireColor='#8064A2'
						$end 'properties'
					$end 'node'
				$end 'EmitCompInstanceExtension'
			$end 'Compinst'
			$begin 'Compinst'
				ID='4'
				Status='Status'
				CompName='EMIT Elements\\Antennas:Antenna'
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '4')
				$end 'Properties'
				$begin 'Parameters'
					ButtonProp('Model', 'OD', '', 'Configure...', '<Project>', 38050, ButtonPropClientData())
					TextProp('Name', 'ID', '', 'UHF-2')
				$end 'Parameters'
				$begin 'EmitCompInstanceExtension'
					$begin 'node'
						fullname='NODE-*-Scene-*-UHF-2'
						$begin 'properties'
							AdjustSourceHeight='false'
							AntennaTemperature='290.0'
							AntennaType='FFPatTable'
							AutoAdjustSrcOrientation='true'
							AutoAdjustmentType='None'
							AutoScaled='true'
							ClearDisplayList1='true'
							ClearDisplayList2='true'
							ClearDisplayList3='true'
							Color='#8064A2'
							LinkChildParameters='true'
							Name='UHF-2'
							NodeOrder='2'
							NumberOfPorts='2'
							Orientation='0.0 0.0 0.0'
							OrientationMode='rpyDeg'
							Parent='NODE-*-Scene'
							PeakGainDBi='0'
							Position='3.700000000000000178 0.000000000000000000 0.100000000000000006'
							PositionDefined='true'
							RadioSidePorts='in'
							ReferencePlane='XY Plane'
							RelativeOrientation='0.0 0.0 0.0'
							RelativePosition='0.0 0.0 0.0'
							ShowAxes='true'
							ShowIcon='false'
							ShowRelativeCoords='false'
							SizeScaler='0.1'
							SrcPosOffset='0.0 0.0 0.0'
							SubType='Isotropic'
							SweCustonNMode='50'
							SweNModeTruncation='Dynamic'
							Type='AntennaNode'
							UseAntennaPattern='false'
							VSWR='1.0'
							Visible='true'
						$end 'properties'
					$end 'node'
					$begin 'node'
						fullname='NODE-*-Scene-*-UHF-2-*-Pattern'
						$begin 'properties'
							AutoScaled='true'
							AxisLabelFont='Sans Serif,12,-1,5,75,0,0,0,0,0'
							AxisTickLabelFont='Sans Serif,10,-1,5,50,0,0,0,0,0'
							ColorByField='true'
							ColorMapClipped='false'
							ColorMapLabel='Normalized Field Density [Linear]'
							ColorMapMax='1'
							ColorMapMax_Locked='false'
							ColorMapMin='0'
							ColorMapMin_Locked='false'
							ColorMapReversed='false'
							ColorMapType='[Spectrum]'
							DBCutoff='-30'
							FillColor='#8064A2'
							Name='Pattern'
							NodeOrder='0'
							Orientation='0 0 0'
							Parent='NODE-*-Scene-*-UHF-2'
							PolType='Composite'
							Position='0 0 0'
							RadPatRenderMode='Flat-shaded'
							ScaleType='Linear'
							SizeScaler='0.019498000000000001'
							Type='RadPatNode'
							Visible='true'
							WireColor='#8064A2'
						$end 'properties'
					$end 'node'
				$end 'EmitCompInstanceExtension'
			$end 'Compinst'
			$begin 'Compinst'
				ID='5'
				Status='Status'
				CompName='EMIT Elements\\Antennas:Antenna'
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '5')
				$end 'Properties'
				$begin 'Parameters'
					ButtonProp('Model', 'OD', '', 'Configure...', '<Project>', 38050, ButtonPropClientData())
					TextProp('Name', 'ID', '', 'VHF-UHF')
				$end 'Parameters'
				$begin 'EmitCompInstanceExtension'
					$begin 'node'
						fullname='NODE-*-Scene-*-VHF-UHF'
						$begin 'properties'
							AdjustSourceHeight='false'
							AntennaTemperature='290.0'
							AntennaType='FFPatTable'
							AutoAdjustSrcOrientation='true'
							AutoAdjustmentType='None'
							AutoScaled='true'
							ClearDisplayList1='true'
							ClearDisplayList2='true'
							ClearDisplayList3='true'
							Color='#8064A2'
							Frequency='30000000'
							LinkChildParameters='true'
							Name='VHF-UHF'
							NodeOrder='3'
							NumberOfPorts='2'
							Orientation='0.0 0.0 0.0'
							OrientationMode='rpyDeg'
							Parent='NODE-*-Scene'
							Position='2.700000000000000178 0.000000000000000000 0.200000000000000011'
							PositionDefined='true'
							RadioSidePorts='in'
							ReferencePlane='XY Plane'
							RelativeOrientation='0.0 0.0 0.0'
							RelativePosition='0.0 0.0 0.0'
							ResonantFrequency='200000000.000000000000000000'
							ShowAxes='true'
							ShowIcon='false'
							ShowRelativeCoords='false'
							SizeScaler='0.1'
							SrcPosOffset='0.0 0.0 0.0'
							SubType='WireMonopole'
							SweCustonNMode='50'
							SweNModeTruncation='Dynamic'
							Type='AntennaNode'
							UseAntennaPattern='false'
							VSWR='1.0'
							Visible='true'
						$end 'properties'
					$end 'node'
					$begin 'node'
						fullname='NODE-*-Scene-*-VHF-UHF-*-Pattern'
						$begin 'properties'
							AutoScaled='true'
							AxisLabelFont='Sans Serif,12,-1,5,75,0,0,0,0,0'
							AxisTickLabelFont='Sans Serif,10,-1,5,50,0,0,0,0,0'
							ColorByField='true'
							ColorMapClipped='false'
							ColorMapLabel='Normalized Field Density [Linear]'
							ColorMapMax='1'
							ColorMapMax_Locked='false'
							ColorMapMin='0'
							ColorMapMin_Locked='false'
							ColorMapReversed='false'
							ColorMapType='[Spectrum]'
							DBCutoff='-30'
							FillColor='#8064A2'
							Name='Pattern'
							NodeOrder='0'
							Orientation='0 0 0'
							Parent='NODE-*-Scene-*-VHF-UHF'
							PolType='Composite'
							Position='0 0 0'
							RadPatRenderMode='Flat-shaded'
							ScaleType='Linear'
							SizeScaler='0.019498000000000001'
							Type='RadPatNode'
							Visible='true'
							WireColor='#8064A2'
						$end 'properties'
					$end 'node'
				$end 'EmitCompInstanceExtension'
			$end 'Compinst'
		$end 'Circuit'
		$begin 'Schematic'
			PPortCounter=0
			BusEntryCounter=0
			ShowVariableBlock=true
			$begin 'Page'
				PageSize('A')
				PageData(Origin(x='0mm', y='0mm'), PageSize(x='0', y='0'), Margins(x='0', y='0'), 0, 0, 0)
				PageNumber=1
				$begin 'SchCompDef'
					SchCompInst('EMIT Elements\\Antennas:Antenna', 'A', '2', 1, '2', 'normal', 0.00508, -0.00508, 0, false, 4294967295, true)
					Levels(0, 1)
					$begin 'PropDisplayMap'
						Name(2, 5, 1, Text(0.00508000000000102, -0.0109608055555679, 0, 3, 5, false, 'Arial', 0, 'GPS', false, false, ExtentRect(0, 0, 0, 0, 0.00508000000000102, -0.011870943011502, 0.00308046523546933, 0.00182027491186824, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'SchCompDef'
				$begin 'SchCompDef'
					SchCompInst('EMIT Elements\\Antennas:Antenna', 'A', '3', 2, '3', 'normal', 0.00508, -0.01524, 0, false, 4294967295, true)
					Levels(0, 1)
					$begin 'PropDisplayMap'
						Name(2, 5, 1, Text(0.00508000000000102, -0.0211208055555679, 0, 3, 5, false, 'Arial', 0, 'UHF-1', false, false, ExtentRect(0, 0, 0, 0, 0.00508000000000102, -0.022030943011502, 0.00406061326493685, 0.00182027491186824, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'SchCompDef'
				$begin 'SchCompDef'
					SchCompInst('EMIT Elements\\Antennas:Antenna', 'A', '4', 3, '4', 'normal', 0.00508, -0.0254, 0, false, 4294967295, true)
					Levels(0, 1)
					$begin 'PropDisplayMap'
						Name(2, 5, 1, Text(0.00508000000000102, -0.0312808055555679, 0, 3, 5, false, 'Arial', 0, 'UHF-2', false, false, ExtentRect(0, 0, 0, 0, 0.00508000000000102, -0.032190943011502, 0.00406061326493685, 0.00182027491186824, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'SchCompDef'
				$begin 'SchCompDef'
					SchCompInst('EMIT Elements\\Antennas:Antenna', 'A', '5', 4, '5', 'normal', 0.00508, -0.03556, 0, false, 4294967295, true)
					Levels(0, 1)
					$begin 'PropDisplayMap'
						Name(2, 5, 1, Text(0.00508000000000102, -0.0414408055555679, 0, 3, 5, false, 'Arial', 0, 'VHF-UHF', false, false, ExtentRect(0, 0, 0, 0, 0.00508000000000102, -0.042350943011502, 0.00602090932387188, 0.00182027491186824, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'SchCompDef'
				$begin 'Properties'
					TextProp('Title', 'D', '', '')
					TextProp('Author', 'D', '', '')
					TextProp('Number', 'D', '', '1')
					TextProp('Project', 'D', '', 'Tutorial 4 - Completed')
					TextProp('ProjectPath', 'D', '', 'C:/Program Files/AnsysEM/v241/Win64/Examples/EMIT/Tutorials/Tutorial 4/')
					TextProp('Design', 'D', '', 'EMIT Design1')
					TextProp('Date', 'D', '', '11:02:13 AM  Jun 30, 2023')
				$end 'Properties'
			$end 'Page'
			GridSetup('1000mil', '100mil', '100mil', 16772075, 16774645, true, true, 16777215, Origin(x='0mm', y='0mm'), PageSize(x='0mm', y='0mm'), Margins(x='0mm', y='0mm'), 0, 0, 0)
			hasWindowBeenOpened=false
			NextUniqueID=0
			MoveBackwards=false
		$end 'Schematic'
		$begin 'Workflow'
			WorkflowName=''
			SpecName=''
			TemplateName=''
			LibLoc=1335920
		$end 'Workflow'
		Notes=$begin_cdata$ $end_cdata$
	$end 'EMIT Design'
	$begin 'DataInstances'
		DesignEditor='TopLevel'
		Refdes('0', 'U1')
		$begin 'CompInstances'
			$begin 'Compinst'
				ID='0'
				Status='Status'
				CompName='EMIT Design1'
				GatesInUse()
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '0')
				$end 'Properties'
			$end 'Compinst'
		$end 'CompInstances'
		$begin 'Instance'
			DesignEditor='EMIT Design1'
			ID='0'
			Refdes('4', 'Antenna3')
			Refdes('5', 'Antenna4')
			Refdes('3', 'Antenna2')
			Refdes('2', 'Antenna1')
			$begin 'EMIT Design'
				DesignInstanceID=1
				$begin 'WindowPosition'
					$begin 'EditorWindow'
						Circuit(Schematic(View(WindowPos(3, -1, -1, -10, -33, 0, 0, 565, 417), Extent(-0.507, -0.507, 1.015, 1.015, 4724.4094488, 4724.4094488, -0.0820207745164765, 0.0224459226473397, 0.171525905156815, 0.0953544011524825, 1.51167642246604), Pages(1, 1, -0.0820207745164765, -0.0729084785051428, 0.0895051306403385, 0.0224459226473397))))
					$end 'EditorWindow'
				$end 'WindowPosition'
				EmitDesignDataVersion=2
				ResultDirectory='EmitDesign1'
				ResultDialogWidth=-1
				ResultDialogHeight=-1
				$begin 'CouplingFolderSettings'
					NodeName='Coupling'
					$begin 'NodeSettings'
					$end 'NodeSettings'
					$begin 'EmitCouplings'
						$begin 'node'
							fullname='NODE-*-Couplings'
							$begin 'properties'
								DisplayName='Coupling Data'
								GlobalDefaultCoupling='0'
								MinCouplingValue='-200'
								Name='Couplings'
								NodeOrder='0'
								Parent='NODE'
								Type='CouplingsNode'
							$end 'properties'
						$end 'node'
						$begin 'node'
							fullname='NODE-*-Couplings-*-Free Space Path Loss'
							$begin 'properties'
								AirTemperature='15.0'
								CustomFadeMargin='0.0'
								Enabled='false'
								EnabledIsReadOnly='false'
								FadingAvailability='90.0'
								FadingModel='NoFading'
								IncludeAtmosphericAbsorption='false'
								IncludeRainAttenuation='false'
								Name='Free Space Path Loss'
								NodeOrder='0'
								Parent='NODE-*-Couplings'
								PointingErrorLoss='0.0'
								PolarizationMismatch='0.0'
								PolarizationTiltAngle='0.0'
								Port1='(all)'
								Port2='(all)'
								RainAvailability='99.99'
								RainRate='8.0'
								RefineAdaptiveEnable='false'
								RefineSamplingEnable='false'
								RefineStartStopStep='1 10e9 1000'
								RefinementFeatureVisible='false'
								ShadowingStdDev='8.0'
								TotalAirPressure='1013'
								Type='PropagationLossCouplingNode'
								WaterVaporConcentration='7.5'
							$end 'properties'
						$end 'node'
						$begin 'node'
							fullname='NODE-*-Couplings-*-ata3'
							$begin 'properties'
								EmIsolation='false'
								Enabled='false'
								EnabledIsReadOnly='false'
								Filename='C:/Program Files/AnsysEM/v241/Win64/Examples/EMIT/Tutorials/Tutorial 4/ata3.s2p'
								MatchedFile='false'
								ModelType='Touchstone'
								Name='ata3'
								NodeOrder='1'
								NumPorts='2'
								Parent='NODE-*-Couplings'
								PortMap='NODE-*-Scene-*-UHF-1|NODE-*-Scene-*-VHF-UHF'
								RefineAdaptiveEnable='false'
								RefineSamplingEnable='false'
								RefineStartStopStep='1 10e9 1000'
								RefinementFeatureVisible='false'
								Type='TouchstoneCouplingNode'
							$end 'properties'
						$end 'node'
						$begin 'node'
							fullname='NODE-*-Scene'
							$begin 'properties'
								DefaultFFVisualization='NODE-*-Analysis::CurrentFFObvDomainNode'
								DefaultNFVisualization='NODE-*-Analysis::CurrentNFObvDomainNode'
								DisplayName='Scene (Antennas/Emitters/Geometry)'
								GroundPlaneNormal='ZAxis'
								GroundPlanePosition='0.0'
								Name='Scene'
								NodeOrder='0'
								NodeVisible='true'
								Parent='NODE'
								Type='EmitSceneNode'
							$end 'properties'
						$end 'node'
						$begin 'node'
							fullname='NODE-*-Scene-*-Fighter_Jet'
							$begin 'properties'
								CADColor='#A0B4C8'
								CADRenderMode='Flat-shaded'
								ColorBy='Entire model'
								Filename='Fighter_Jet.facet'
								Name='Fighter_Jet'
								NodeOrder='4'
								Orientation='0.0 0.0 0.0'
								OrientationMode='rpyDeg'
								ParametricModelBaseRadius='2.0'
								ParametricModelCenterRadius='1.0'
								ParametricModelClosedBase='true'
								ParametricModelClosedTop='true'
								ParametricModelCoatingIndex='1'
								ParametricModelDihedralAngleDeg='90.0'
								ParametricModelEllipsoidAx='3.0'
								ParametricModelEllipsoidBy='2.0'
								ParametricModelEllipsoidCz='1.0'
								ParametricModelHeight='1.0'
								ParametricModelLength='1.0'
								ParametricModelMeshDensity='5'
								ParametricModelMeshOption='Improved'
								ParametricModelMeshUseCenterPoint='false'
								ParametricModelNumSides='4'
								ParametricModelParabFocalLength='0.5'
								ParametricModelParabOffset='0.0'
								ParametricModelPrismDirection='0 0 1'
								ParametricModelRadius='1.0'
								ParametricModelSide='1.0'
								ParametricModelTopRadius='0.75'
								ParametricModelTopSide='0.75'
								ParametricModelType='Plate'
								ParametricModelWidth='1.0'
								ParametricModelXDirTaperPercent='100'
								ParametricModelYDirTaperPercent='100'
								Parent='NODE-*-Scene'
								Position='0 0 0'
								RelativeOrientation='0.0 0.0 0.0'
								RelativePosition='0.0 0.0 0.0'
								ShowAxes='true'
								ShowRelativeCoords='false'
								Transparent='false'
								Type='CADNode'
								Visible='true'
							$end 'properties'
							$begin 'files'
								$begin 'file'
									property_name='Filename'
									file_content=$begin_cdata$ Exported from Delcross TriModel writer
1
BigPart
0
3826
3.4010098582037709 -0.45273777240715202 -0.96605070388793945
4.0070162403448837 -0.43357978239021472 -0.95728505676269537
4.0070162403448837 -0.67550232191047843 -0.97823078407287611
3.4010098582037709 -0.68702633264503654 -0.98946350929260263
6.9963646653326759 -0.1228603207118551 -0.64808775007247932
6.9963656730231065 -0.23833626621208365 -0.64943068651199354
6.7818102421149034 -0.23202166073284325 -0.67835146482467656
6.7818092344244727 -0.1228603207118551 -0.67376883514404307
7.7828358073004509 -0.79475146264991936 -0.76048150983810436
7.7828358073004509 -0.73640517908058345 -0.79166801710128787
7.7854144871100202 -0.69852830015144518 -0.69769127998352054
7.7854144871100202 -0.73924447282753158 -0.67592815828323372
3.3811644028815047 -2.7579977571674363 -0.2226907628250123
1.9134653074225207 -1.4212058360095996 -0.20186835163116462
2.0079564390143174 -1.4322122087665574 -0.25337717222213757
8.6453261075934176 -1.19539324338875 -0.43775425865173351
8.6453261075934176 -1.2999478014179247 -0.43719810800552378
8.6453261075934176 -1.2999478014179247 -0.53871743947982798
8.6453261075934176 -1.19539324338875 -0.53876664311409006
4.5196278580816998 -0.23827833975753956 -0.85403082876205461
5.1034443931158799 -0.23942650853119071 -0.84222438129425048
5.1034443931158799 -0.35652367912254507 -0.92150908641815199
4.5196278580816998 -0.35454871609649835 -0.93275472267150883
2.0079564390143174 -0.23271229081592731 0.12673074317932126
2.7050912897833608 -0.18709652258358175 0.077956636962890499
2.7050907859381459 -0.12286045762096742 0.083220244941711291
2.0079559351691025 -0.12286045759021515 0.14114184997558582
0.33469051127994204 -0.37550795275650195 -0.79593662525177011
0.33469051127994204 -0.26910643987617666 -0.86452305896759041
0.9820378971442002 -0.26960420745811636 -0.85929569635391245
0.9820378971442002 -0.38090833896598991 -0.79156857065200814
-0.093891564983485706 -0.32900555865249803 0.334083643760681
-0.079480080303309789 -0.35882611004791432 0.24490902389526351
0.32608886577212964 -0.33117177817306692 0.27237960971832259
0.33469051127994204 -0.31112385580024893 0.30060949028015127
-2.1520582042351943 -0.3484076616760271 -0.093627536048889279
-2.1520582042351943 -0.28251794925651724 -0.053678593673706178
-2.4738706929436902 -0.27110724071464715 -0.13342463207244881
-2.4738706929436902 -0.33235726298294238 -0.16959873460769664
4.0070162403448837 -0.3633863343616503 -0.93524982715606697
3.4010098582037709 -0.38042203386268791 -0.93656032855987548
3.4010098582037709 -0.2670936884590166 -0.83872989982604984
4.0070162403448837 -0.23846585677585777 -0.84966677343368535
4.5196278580816998 -0.37602396898231677 -0.10572051399230964
4.5196278580816998 -0.28314441780052357 -0.11166777694702155
4.0095732548102161 -0.31756469812355215 -0.081470254859924374
4.0095732548102161 -0.42462320941887077 -0.083792414474487389
6.1403548221930278 -1.0105022033496875 -0.72123152673721314
6.1403548221930278 -1.0246875874897021 -0.60189199301719676
5.797128408008458 -1.027137031001665 -0.61714126207351694
5.797128408008458 -1.0204962880893726 -0.72785979948043833
-0.20900936390316299 -0.38358827591858086 0.3446720769119262
-0.21951630009090745 -0.30784020206413443 0.42798811058044417
-0.21488822986996003 -0.28337925690612964 0.39057924087524404
-0.2056613124505263 -0.3491095967861193 0.31791266860961914
-0.23145717976009675 -0.32632540126762566 -0.80976862495422364
-0.68015426853573169 -0.32738568054161249 -0.80563183530807503
-0.68015426853573169 -0.2394618879123705 -0.85868771263122567
-0.23145717976009675 -0.24030246705494099 -0.86282450227737439
3.4010098582037709 -1.3933125870319383 -0.12085974010467541
4.068142237964512 -2.7579977571674363 -0.16537534656524666
3.9465301261481067 -1.1289019870182055 -0.15114568702697764
-3.6871823701897846 -0.15814329742632086 -0.50402846795082101
-3.4731469075432999 -0.17327676080904181 -0.4244125948143006
-3.473594322094081 -0.12286045759021515 -0.42062034082412725
-3.6874877003899793 -0.12286045755946289 -0.50143620006561285
6.7818102421149034 -0.3690172612472552 -0.83312887300491334
6.4318998173102155 -0.36628717595062432 -0.85376756963729872
6.4318998173102155 -0.30488305577240166 -0.80485966102600104
6.7818102421149034 -0.30274291024170097 -0.77633978605270393
7.3690035477789655 -1.2595744324298876 1.7092159814453125
7.5401325596197859 -1.2410295275684373 1.7092159814453125
7.0067610074957623 -1.2259747585102099 -0.28011951276779185
6.7530910648688094 -1.2223440498920457 -0.27203301750183112
3.4010098582037709 -0.2670936884590166 -0.83872989982604984
2.7019815571173447 -0.32824763374290633 -0.83436171926498415
2.7019810532721293 -0.12286045762096742 -0.83658244853973396
3.4010088505133407 -0.12286045755946289 -0.83658244853973396
-1.7509742363396865 -0.12311901555373544 0.085419592285156151
-1.735664899486659 -0.22207108775100884 0.065478910217285025
-1.0835602071038466 -0.23624696181259328 0.37355223270416255
-1.0826484991875871 -0.12311938310488336 0.40060702026367173
0.33469051127994204 -0.4938955339237231 -0.50269330962181091
0.3339226511725204 -0.50859417888603387 -0.37469236175537118
-0.23145717976009675 -0.51966557916603262 -0.4158287728309632
-0.23145717976009675 -0.5034310250469225 -0.49531481135368355
-0.20567088550960874 -0.91623817998848134 -0.23074460262298596
-0.20580919102108322 -0.74276112348518553 -0.22471571674346932
0.98397215892398515 -0.76281706014595207 -0.27662654283523563
0.98397215892398515 -0.89974871168098625 -0.28138532939910899
6.9963656730231065 0.19920707508125132 -0.85488972740173352
6.9963656730231065 0.12586686176338022 -0.81568852281570448
6.7818102421149034 0.12330570632018871 -0.83312893598556526
6.7818102421149034 0.19891755302467171 -0.86051210466384898
-0.29427055500423749 -0.91668420896492175 -0.1938293752670289
-0.29427055500423749 -0.74343986597023182 -0.18747906763076791
0.98397215892398515 -0.76340057588539301 -0.6764101807022096
0.92069474223697367 -0.74350057931862046 -0.73119777402877817
0.9209234879645124 -0.90804194093666246 -0.73119764806747445
0.98397215892398515 -0.89327889825782947 -0.67641008623123178
6.4318998173102155 -0.99450776296577625 -0.7088676060295106
6.4318998173102155 -1.0199561030384081 -0.61862373214721689
-2.4738706929436902 -0.20464695507965261 -0.11114869041442879
-2.4738711967889055 -0.12286045762096742 -0.10362703712463386
-2.8637662739983778 -0.1228604576517197 -0.21539354108810438
-2.8630054677239638 -0.1977456061025637 -0.22183523365020758
4.5196278580816998 -0.41709664363823107 -0.95911244037628174
4.0070162403448837 -0.3633863343616503 -0.93524982715606697
7.7828358073004509 -0.26977512120208913 -0.47987565563201912
7.7828358073004509 -0.27625978231392079 -0.41403621751785286
7.7854144871100202 -0.37742193476638963 -0.43416595175743111
7.7854144871100202 -0.3728966962047594 -0.48011114028930674
2.7019815571173447 -0.42928749351463485 -0.92793090858459482
2.7019815571173447 -0.32824763374290633 -0.83436171926498415
-0.96183951664364176 -0.43730323001823596 0.10429766479492174
-0.9619072838250381 -0.42763862855873286 0.22819641513824462
-1.0211919791070208 -0.4249926854129808 0.22709211238861068
-1.0211919791070208 -0.43796339321098499 0.1040827118301391
-1.6814199159661514 -0.48372296201667958 -0.63806145072937026
-1.0211919791070208 -0.44435051303825551 -0.64332228755950938
-1.0211919791070208 -0.48511782600364856 -0.56614179750442517
-1.6814199159661514 -0.51050863325081042 -0.5633078098773957
6.4318998173102155 -0.92517078882179438 -0.13757593875885016
6.1403548221930278 -0.92064984868965327 -0.12529364097595222
6.1403548221930278 -0.97228970052681141 -0.17658448553085335
6.4318998173102155 -0.97601544694862541 -0.19544212081909187
-0.19354635425960831 -0.37627039652786431 0.22275060413360584
-0.68015426853573169 -0.38628123412094284 0.26884406486511225
-0.68015426853573169 -0.39577574058494741 0.16766212074279777
-0.19085959965145402 -0.37760821578941522 0.20189607280731187
6.7631498307379498 -0.44556386678657706 -0.056250471572876048
6.7631498307379498 -0.52762079126320061 -0.032337977676391676
7.0049008109625595 -0.52877258142433337 -0.057003783149719343
7.0049008109625595 -0.44970090835533316 -0.080473963928222744
6.9963656730231065 -0.30729530920944387 -0.76293246488571176
6.9963656730231065 -0.25912984801254446 -0.69864918420791633
7.2567780723150985 -0.29026715164146599 -0.68043788785934456
7.2567780723150985 -0.33767915955505545 -0.73820978788375868
6.4318998173102155 -0.67550225892982652 -0.90269745849609395
6.1403548221930278 -0.67550232191047843 -0.91218272254943855
6.1403548221930278 -0.56669039777717767 -0.91525957931518576
6.4318998173102155 -0.5638300055118578 -0.90060908306121834
5.7686903763922466 -1.0316203087039963 -0.22082880283355719
5.7686903763922466 -0.98256291551552 -0.18263015575408945
5.1173092057379499 -0.96100010377845935 -0.14084135959625252
5.1173092057379499 -0.96100010377845935 -0.14084135959625252
5.1034443931158799 -1.0495421459766405 -0.15375233024597179
5.7686903763922466 -1.0316203087039963 -0.22082880283355719
4.5190373514899038 -0.12286045768247197 -0.08943699241638188
4.0095732548102161 -0.20031982215843375 -0.080204532699585024
2.0079564390143174 -1.3550447871967335 -0.32811684711456307
2.0079564390143174 -1.0936486931034104 -0.44243605136871345
2.7019815571173447 -1.0802651156421679 -0.52692823296546953
2.7019815571173447 -1.4547279177661914 -0.31837906213760386
0.98397215892398515 -0.96495667428932363 -0.67641055858612065
0.98397215892398515 -0.97150414285621822 -0.45872848470687871
0.98397215892398515 -0.89325389493904273 -0.45805097034454351
0.98397215892398515 -0.89327889825782947 -0.67641008623123178
7.7847504191168566 -0.73640536802253898 -0.16808326267242443
7.2899814719733023 -0.7523072268482226 -0.11950534118652356
7.2899814719733023 -0.81799025251350577 -0.15394574382781989
7.7847504191168566 -0.79475158861122308 -0.19926989589691166
0.98397215892398515 -0.73160473081550781 -0.6764101807022096
0.92069474223697367 -0.70321840631447019 -0.73119780551910407
-2.1520582042351943 -0.51046360208473374 -0.53741320465087894
-2.1520582042351943 -0.51778658290825064 -0.45307499500274673
-2.4738706929436902 -0.48980925476036241 -0.49508146803855901
-2.4738706929436902 -0.48300189653358633 -0.5714504051589967
6.9963656730231065 -1.0444327146335619 -0.6144362430763245
7.2567780723150985 -1.0498406742664355 -0.60858543498992923
7.2567780723150985 -1.3758058552356738 -0.60514601435661319
6.9963656730231065 -1.4052450272937793 -0.61498319854736339
-3.6746572819939831 -0.2827193298908251 -0.61002707785606392
-3.4548245763055068 -0.34789625878296065 -0.57948084764480601
-3.4591984566155656 -0.33524905110321218 -0.54245658503532423
-3.6776476033440808 -0.27369659574470695 -0.58471875951766972
6.9963656730231065 -0.84293462140999009 -0.81568893218994154
6.9963656730231065 -0.76064025987587147 -0.85718716711044307
7.2567780723150985 -0.75315085267982662 -0.82085262136459369
7.2567780723150985 -0.81906224618873769 -0.78562228389739996
-3.8436469670525772 -0.22875008353672199 -0.65164968381881727
-3.6715475493279679 -0.28576590870819263 -0.6363468339729309
-3.8454950713006242 -0.22675436838588889 -0.63600510095596319
1.0076745493658799 -0.90801032464943099 -0.77226169437408454
1.0074452997931258 -0.74344018087349117 -0.77226169437408454
1.0272519590338489 -0.74343999193153554 -0.88317786506652851
1.0274807047613876 -0.9080103876300829 -0.88317786506652851
4.5196278580816998 -0.61225170349083113 -0.055282207031250107
4.5196278580816998 -0.70545365262947257 -0.06201861755371104
5.1173092057379499 -0.69902654008827392 -0.02881005348205579
5.1173092057379499 -0.61211068981132688 -0.019671812820434658
-3.9414498732415422 -0.16106824485979254 -0.63426003305435186
-3.8503465968743544 -0.19832895651779348 -0.59494571521759043
-3.8515255946770885 -0.18258973341665441 -0.584972713251114
-3.9421240181390029 -0.15281257372222121 -0.62855855209350597
7.2899814719733023 -0.53485575662574947 -0.099916091156005943
7.2899814719733023 -0.61211068981132688 -0.087392766418457155
7.7847504191168566 -0.60725670799217391 -0.1423940216064454
7.7847504191168566 -0.54141723838768174 -0.14887857250213635
7.7828337919195896 -0.1228604576517197 -0.60138569155693067
7.7828358073004509 -0.29546423630676444 -0.60902378032684334
7.2567780723150985 -0.25503687715492424 -0.61452643136978158
7.2567770646246688 -0.12286045768247197 -0.60138600646018991
7.7828358073004509 -0.67550232191047843 -0.81087270727157601
7.7854144871100202 -0.65602801156959711 -0.71109302736282365
2.0079564390143174 -0.012999264111139134 0.12673080615997304
2.7050912897833608 -0.058615040216066193 0.077956699943542387
2.7050912897833608 -0.0080806405254381271 0.063579791641235256
2.0079564390143174 0.051969616070173426 0.10972628208160387
6.2223727616461533 -3.929174118709184 -0.30915132596969613
5.9688187034186146 -2.7574326947589891 -0.30988608974456794
6.0242326078375585 -2.7574326947589891 -0.27267863216400157
6.2591333085211529 -3.9126684013935105 -0.27012788427352913
7.6574851639899029 -0.51827909160576036 -0.26253096910476686
7.6574851639899029 -0.47756304489097767 -0.28429415378570566
7.7854144871100202 -0.47756304489097767 -0.28429415378570566
7.7854144871100202 -0.51827902862510855 -0.26253096910476686
7.6574851639899029 -0.56245831840477167 -0.71109293289184572
7.6574851639899029 -0.60840345970115839 -0.71561818719863901
7.7854144871100202 -0.60840345970115839 -0.71561818719863901
7.7854144871100202 -0.56245831840477167 -0.71109293289184572
7.6574851639899029 -0.65602801156959711 -0.71109302736282365
7.7854144871100202 -0.65602801156959711 -0.71109302736282365
7.2567780723150985 -0.67550232191047843 -0.84254737756729126
7.7828358073004509 -0.67550232191047843 -0.81087270727157601
7.7828358073004509 -0.73640517908058345 -0.79166801710128787
-3.1257582280389054 -0.28735453267059502 -0.8110189168548585
-2.7912191130486712 -0.31498532552681141 -0.8293926717948914
-2.7961447038689835 -0.36426993716201961 -0.78770014156341561
-3.1296761284295305 -0.32963819930038624 -0.77786212287902845
7.7854144871100202 -0.4125867881008165 -0.34927037908554087
7.7847504191168566 -0.32665099549255538 -0.29238090097427377
7.7847504191168566 -0.36862116018257318 -0.24124013931274424
7.7854144871100202 -0.44187505851707631 -0.31358248718261728
7.7854144871100202 -0.51827877670250111 -0.69769115402221693
7.7854144871100202 -0.47756272998771843 -0.67592790636062627
7.6574851639899029 -0.47756272998771843 -0.67592790636062627
7.6574851639899029 -0.51827883968315291 -0.69769115402221693
7.6574851639899029 -0.39082344596824825 -0.5702354454040528
7.7854144871100202 -0.39082344596824825 -0.5702354454040528
7.7854144871100202 -0.37742184029541193 -0.5260559194469453
7.6574851639899029 -0.37742184029541193 -0.5260559194469453
7.6574851639899029 -0.83938566167793438 -0.43416599899292002
7.7854144871100202 -0.83938566167793438 -0.43416601473808297
7.7854144871100202 -0.84391088449440177 -0.48011120326995854
7.6574851639899029 -0.84391088449440177 -0.48011118752479565
6.1403548221930278 -1.0157129075809497 -0.21680610263824468
6.4318998173102155 -1.0219265157123583 -0.25013984075546269
-2.1520582042351943 -0.51046360208473374 -0.36873675386428845
-1.6814199159661514 -0.53820226505241575 -0.41262042820930489
-1.6814199159661514 -0.52878527202568237 -0.33459355691909798
7.6574851639899029 -0.80422072961769275 -0.61095194872856151
7.6574851639899029 -0.82598394578895729 -0.57023585477828986
7.7854144871100202 -0.82598394578895729 -0.57023585477828986
7.7854144871100202 -0.80422072961769275 -0.61095194872856151
7.6574851639899029 -0.41258653617820912 -0.61095157084465035
7.6574851639899029 -0.44187486957512073 -0.64663954147338876
7.7854144871100202 -0.44187486957512073 -0.64663954147338876
7.7854144871100202 -0.41258653617820912 -0.61095157084465035
4.0095732548102161 -0.61136427461586174 -0.079078501625061137
4.0095732548102161 -0.71210371667823968 -0.075626217193603615
7.7828358073004509 -0.60725636159858887 -0.8173572581672669
7.7854144871100202 -0.60840345970115839 -0.71561818719863901
7.6574851639899029 -0.77493245920143294 -0.31358248718261728
7.6574851639899029 -0.7392445358081835 -0.28429415378570566
7.7854144871100202 -0.7392445358081835 -0.28429415378570566
7.7854144871100202 -0.77493245920143294 -0.31358248718261728
5.797128408008458 -0.40876027263603382 -0.92195580818176281
5.797128408008458 -0.3554459542079943 -0.8971057843017578
6.1403548221930278 -0.35761447252235584 -0.8768210704231264
6.1403548221930278 -0.42593371082267933 -0.90581455989837656
6.7631498307379498 -0.97275153764686761 -0.21441863208770756
6.7631498307379498 -0.91895189031562985 -0.1498771307373048
-0.29427055500423749 -0.91902853776893789 -0.12292178962707526
-0.29427055500423749 -0.74343986597023182 -0.11604587696075447
-0.29427055500423749 -0.74343986597023182 -0.18747906763076791
-0.29427055500423749 -0.91668420896492175 -0.1938293752670289
7.2899814719733023 -0.9224541184040087 -0.2588909708404542
7.0049008109625595 -0.95529487546882808 -0.23095993347167976
7.0049008109625595 -0.99052297712288073 -0.30289117513656627
7.2899814719733023 -0.95746947141609362 -0.32443288835525519
1.6732994242438095 1.1079794946483594 -0.14345373405456555
1.9134653074225207 1.1754945015148146 -0.20186835163116462
1.6732994242438095 1.1475193776897412 -0.20102576498031627
-1.6813871660271866 -0.50821629497490095 -0.23839228019714365
-2.1520582042351943 -0.48877599418602163 -0.28763962303161628
7.7854144871100202 -0.56245853883705321 -0.24912928470611584
7.6574851639899029 -0.56245860181770502 -0.24912928470611584
-3.8341711500970108 -0.1228604576517197 -0.73184121585845963
-3.8343535420647843 -0.14514876719675238 -0.73030033123016369
-3.9323060902825575 -0.13317374315760311 -0.71164155735015877
-3.9322012904778698 -0.12286032086561646 -0.71252246772766126
7.2567780723150985 -0.93004272012672595 -0.68043848617553715
6.9963656730231065 -0.95997351915321516 -0.69864987699508674
6.9963656730231065 -0.90373267877540753 -0.75874856571197524
7.2567780723150985 -0.87546948144874737 -0.7375432636451722
1.6732994242438095 -0.95165572744331528 -0.047815850753784285
2.0079564390143174 -0.95959626504860096 -0.035276654891967844
2.0079564390143174 -0.74907430402717767 -0.025304361457824814
1.6732994242438095 -0.74907442998848139 -0.038963731193542572
0.9820378971442002 -1.2495236021228806 -0.15278330993652353
1.3084782041510363 -1.3011946923633593 -0.14563097518920912
1.3276686606940045 -1.1735230860706347 -0.095800746421814034
0.9820378971442002 -1.1606157053180712 -0.13295851226806646
5.3302694626959575 -2.7574329466815963 -0.32345656229019176
4.0658799729498636 -2.7579977571674363 -0.30261594968795785
4.5235900968512306 -1.4747048766895312 -0.39561821866989144
5.1034443931158799 -1.5072661256214159 -0.39600268405914313
6.4318998173102155 -0.70804807760200683 -0.016672926101684624
6.4318998173102155 -0.79023530904731931 -0.045367225990295461
6.7631498307379498 -0.77937001295051755 -0.056222886047363335
6.7631498307379498 -0.69817189264259516 -0.030226362380981499
6.7818102421149034 -0.67550238489113024 -0.88539982246398941
6.7818102421149034 -0.76306973852119619 -0.86441608633041378
6.4318998173102155 -0.77174847234687971 -0.89039387325286878
7.6574851639899029 -0.77493239622078114 -0.646639856376648
7.7854144871100202 -0.77493239622078114 -0.646639856376648
6.9963656730231065 -0.67550232191047843 -0.87902983337402352
6.9963656730231065 -0.60725633010826285 -0.8871809152984621
7.2567780723150985 -0.60725645606956657 -0.84987272016525273
7.6574851639899029 -0.44187505851707631 -0.31358248718261728
7.6574851639899029 -0.4125867881008165 -0.34927037908554087
7.7854144871100202 -0.4125867881008165 -0.34927037908554087
7.7854144871100202 -0.44187505851707631 -0.31358248718261728
7.6574851639899029 -0.39082357192955192 -0.38998645729064946
7.6574851639899029 -0.37742193476638963 -0.43416593601226816
7.7854144871100202 -0.37742193476638963 -0.43416595175743111
7.7854144871100202 -0.39082357192955192 -0.38998645729064946
7.2567780723150985 -0.25503687715492424 -0.61452643136978158
7.7828358073004509 -0.29546423630676444 -0.60902378032684334
7.7828358073004509 -0.32665075931511095 -0.66737003240585335
-0.1342236186639052 -0.91970085622749498 -0.11706125102996831
0.3744721140631454 -0.94311051259956535 -0.097190855369567924
0.37424387218082106 -0.74623570306739984 -0.089407958335876572
-0.13445211246883712 -0.73567239919624505 -0.10927847995758065
4.0095732548102161 -0.7907683143039721 -0.083587790336609014
4.0095737586554305 -0.87883145162544418 -0.0914522473144532
4.5196278580816998 -0.85363333368263417 -0.10551135524749768
4.5196278580816998 -0.78371863801918207 -0.078656090393066536
-3.4718192754021864 -0.2149690666719454 -0.43564377700805673
-3.1810552403680066 -0.23911341596565422 -0.34301964385986339
-3.1828479216424208 -0.18676871616325549 -0.32784782526016243
7.7828358073004509 -0.60725636159858887 -0.8173572581672669
-3.9426248402825577 -0.1433937680336016 -0.62432212705612189
-3.8524002699700577 -0.16463300879917317 -0.57756244124412548
-3.8529398881951558 -0.1451487849100607 -0.57299908364295959
-3.9429321858636124 -0.13317375890276603 -0.62171327951431277
2.0079564390143174 -0.58164165813408075 -0.98322483486175549
1.6732994242438095 -0.60561751056633173 -0.96538758060455332
1.6732994242438095 -0.55779982852897825 -0.92342691024780288
2.0079564390143174 -0.48746476850471665 -0.9347760237121584
0.73980322551334099 -0.41115016794166737 0.17685565841674794
0.71878280315005971 -0.31896913516960318 0.25687604053497304
0.33469051127994204 -0.38108614909134081 0.2138529495620726
0.33469051127994204 -0.45907655458412339 0.13713476898193352
0.74193902537906342 -0.20757661818943196 0.30653842586517316
0.76975833507144586 -0.12288438568658407 0.32420185352325437
0.3346900074347276 -0.12340856442629571 0.38803179946899408
0.33469051127994204 -0.21911926332435783 0.36319600921630857
1.0074452997931258 -0.6072394198032397 -0.77226169437408454
1.0272519590338489 -0.61499435342750719 -0.88317786506652851
5.1034443931158799 -1.024162517795183 -0.82239715887069709
4.5196278580816998 -1.0394348850055712 -0.81944843624114994
4.5196278580816998 -0.99402501626930406 -0.91656183025360116
5.1034443931158799 -0.98300919641456785 -0.90896390739440924
0.3339226511725204 -0.51882283506355464 -0.28955275480270393
-0.23145717976009675 -0.53379387134514023 -0.33334572126388562
0.3339226511725204 -0.51882283506355464 -0.28955275480270393
0.3339226511725204 -0.50859417888603387 -0.37469236175537118
0.33401586253726651 -0.56740922744713007 -0.37441342044830328
0.33401586253726651 -0.56740922744713007 -0.28838947067260751
2.0079559351691025 -1.1061839211841602 -0.88576592899322526
2.7019815571173447 -1.0887120806690234 -0.81618307838439952
2.7019815571173447 -1.0802651156421679 -0.52692823296546953
2.0079564390143174 -1.0936486931034104 -0.44243605136871345
2.0079559351691025 -1.1061839211841602 -0.88576592899322526
0.9820378971442002 -1.2894761343952197 -0.21057523780822759
1.3084782041510363 -1.3438910397144335 -0.2086340166664124
0.9820378971442002 -1.2495236021228806 -0.15278330993652353
6.4318998173102155 -0.52651025342903313 -0.016038081130981499
6.4318998173102155 -0.61211072130165278 -0.0018082326507568901
6.7631498307379498 -0.61211065832100087 -0.019105994644165163
-0.10741653400814348 -0.22817399951420003 0.46015623428344715
-0.10915605961239153 -0.12299624836544717 0.47206234863281238
-0.16687984241878845 -0.12299830298620486 0.48057682891845699
-0.16518138019954987 -0.23266574024162465 0.46738414581298815
-1.0832616788140519 -0.25680523215255913 0.40297332931518548
-1.0835602071038466 -0.23624696181259328 0.37355223270416255
-1.0859010719720108 -0.31709232748947319 0.30438524333953848
-1.0856980223504289 -0.35253385482750116 0.32807220352172839
-3.6848017015496479 -0.21529923486671623 -0.52417248305320752
-3.6862744411126354 -0.18788718562326606 -0.51170566770553594
6.4318998173102155 -0.36210541811905084 -0.078816250190734918
6.1403548221930278 -0.35348487841568166 -0.075346268196106056
6.1403548221930278 -0.4342234446521776 -0.035116306152343874
6.4318998173102155 -0.44082022706947499 -0.038526204605102643
7.0049008109625595 -0.76766298044166736 -0.077553551101684659
7.0049008109625595 -0.8403234435840623 -0.11494226699829106
-0.23145717976009675 -0.54260949361763178 -0.15433716857910162
-0.23145717976009675 -0.51883536821327381 -0.039600087699890187
-0.68015426853573169 -0.51713948820076161 -0.058553044204711982
-0.68015426853573169 -0.54221712415657219 -0.15020034744262706
6.7818102421149034 -0.92168392801246823 -0.76815970153808599
6.7818102421149034 -0.84430224626503159 -0.82524265621185311
6.7631498307379498 -0.37023747988662892 -0.096777513351440553
7.0049008109625595 -0.37835831535301384 -0.11964912601470952
-1.0856980223504289 -0.35253385482750116 0.32807220352172839
-1.0876448802605851 -0.41536247138939075 0.22344956340789793
-1.0211919791070208 -0.36731190264663871 0.3408674787139892
7.0049008109625595 -0.25453978661499199 -0.22729367227554328
7.0049008109625595 -0.3158847364707964 -0.17116692134857187
7.2899814719733023 -0.34087972606620964 -0.2037511267280579
7.2899814719733023 -0.29026738781891043 -0.25682722084045417
7.2567780723150985 -1.3817814594837206 -0.35105651037216196
7.2567780723150985 -1.3683653210254687 -0.34757213729858405
6.9963656730231065 -1.3719691998859422 -0.33001265920639045
6.9963656730231065 -1.411626856746294 -0.33001924068450939
0.33469051127994204 -0.52005161907158071 -0.15434182914733899
0.9820378971442002 -0.51550756504020856 -0.19296433601379404
0.9820378971442002 -0.50679708896598985 -0.09014161994934089
0.33469051127994204 -0.51332748977623155 -0.0660930878448487
2.7050912897833608 -0.59321765939674553 -0.036456030578613387
2.7050912897833608 -0.47182109886131463 -0.039333742523193445
2.0079564390143174 -0.48193346126518427 -0.022294579086303765
2.0079564390143174 -0.58477774820289785 -0.023979059600830167
0.67819353648746172 0.890120287685774 -0.096073893508911185
0.9820378971442002 0.90839544641532721 -0.084266910705566453
0.81775211101138734 0.90638460016288569 -0.15347723075866709
6.7631498307379498 -1.0076372134967821 -0.28173569076538096
2.7019815571173447 -0.52522686519584838 -0.97076423885345464
2.7019815571173447 -0.69167468263588128 -0.98570778408050552
7.2899814719733023 -0.39792356975517451 -0.15675757801055917
-0.29427055500423749 -0.74343986597023182 -0.11604587696075447
-0.29427055500423749 -0.91902853776893789 -0.12292178962707526
-3.1204487071648814 -0.12286045755946289 -0.8559512977790833
-2.784542156261562 -0.12286045759021515 -0.88589239414215093
-2.7853039702264053 -0.19774552737674886 -0.87945073307037358
-3.1210543291131239 -0.18676864137373145 -0.85082842006683368
6.9963656730231065 -0.23833626621208365 -0.64943068651199354
0.32608886577212964 -0.37363701802215749 0.27205513339996334
0.32608886577212964 -0.33117177817306692 0.27237960971832259
-0.075138194164393768 -0.35879495037040887 0.21755425949096679
-0.074265786174891379 -0.40688785785637077 0.21722449279785153
5.9105973734625596 -4.0859783072467817 -0.21049607112884527
6.2236787284430282 -3.929174118709184 -0.22991413974761971
5.9701246702154886 -2.7574326947589891 -0.24005698478698737
5.3325317277106059 -2.7574329466815963 -0.20775253946304331
5.0301510374029883 -4.3286299107929249 -0.19396550794601444
5.0301510374029883 -4.3286299107929249 -0.19396550794601444
5.4434895286139273 -4.3231269133564005 -0.18234510532379156
5.4410398331793557 -4.3231269133564005 -0.33098186845779426
5.0283079716070906 -4.3286299107929249 -0.30574542678833017
0.33469051127994204 -0.41843863536796738 -0.70260893524169932
0.33469051127994204 -0.37550795275650195 -0.79593662525177011
0.9820378971442002 -0.38090833896598991 -0.79156857065200814
0.9820378971442002 -0.45011226648292713 -0.69707706117630008
4.007016744190099 -0.96193473665199447 -0.96425638511657719
3.4010098582037709 -0.98618424001655747 -0.96495641506195073
6.7818102421149034 -0.97563743707618877 -0.69943250606536866
6.9963656730231065 -1.0088628169818896 -0.61255938816070565
6.7818102421149034 -1.0168110382267015 -0.61547876180648808
3.4577992600592391 -2.7579982610126512 -0.27985908777236951
5.8253004093512315 -1.506561498088457 -0.24427775913238531
6.1393955009039658 -1.5064278531452198 -0.2866611241340638
5.8253004093512315 -1.508625248088457 -0.48830849724769604
5.8253004093512315 -1.508625248088457 -0.35735813396453869
5.1034443931158799 -1.5072661256214159 -0.39600268405914313
5.1020547880133398 -1.2640086482044237 -0.24217086738586438
5.9688187034186146 -2.7574326947589891 -0.30988608974456794
5.8253004093512315 -1.508625248088457 -0.35735813396453869
7.6574851639899029 0.59819929807700933 -0.48011121901512155
7.6574851639899029 0.59367407526054206 -0.43416603048324592
7.5314523142584582 0.36274471405067271 -0.48011114028930674
7.6574851639899029 0.13171039558448619 -0.43416596750259401
7.6574851639899029 0.14511207998313727 -0.38998648878097542
-0.12453140018856369 0.16115608614005866 0.15166075248718261
0.33469051127994204 0.21336506263770888 0.13713476898193352
-0.2314574316827043 0.22911960971870249 0.059876907196044868
7.2567790800055274 1.1226542384532909 -0.34757213729858405
7.7828358073004509 1.1100786397747022 -0.37123428310394296
7.2567790800055274 1.1360701249889356 -0.35105651037216196
7.2567790800055274 0.73791733961143313 -0.58375728114128123
7.7828358073004509 0.69254229917564214 -0.54571521970748915
7.7828358073004509 0.67333754602470219 -0.60902447311401375
7.6574851639899029 0.23185126953162974 -0.67592796934127808
7.6574851639899029 0.19616340911903205 -0.64663960445404056
7.6574851639899029 0.36269199924506967 -0.71561825017929082
7.6574851639899029 0.3167468579486829 -0.71109299587249764
7.6574851639899029 0.27256763114967175 -0.26253096910476686
7.6574851639899029 0.3167471098712904 -0.24912928470611584
7.6574851639899029 0.36269225116767706 -0.24460406188964851
6.9963656730231065 0.76315148248710452 -0.61255945114135757
6.7818102421149034 0.77109964075126469 -0.61547882478713989
6.9963656730231065 0.79872125417747331 -0.61443630605697641
7.6574851639899029 0.5292207468227369 -0.64663991935729981
7.6574851639899029 0.49353288641013926 -0.67592822126388563
7.6574851639899029 0.45281671373405274 -0.69769134296417246
7.6574851639899029 0.4103165511135084 -0.71109309034347545
7.6574851639899029 0.45281677671470466 -0.26253096910476686
7.6574851639899029 0.49353307535209473 -0.28429415378570566
3.4045292170294545 -0.058615008725740256 0.0078751055526732304
4.0095737586554305 -0.073175407220937558 -0.055098933334350689
3.4045292170294545 -0.027737209000207725 -0.0063102156066895789
4.5190373514899038 -0.12286045768247197 -0.08943699241638188
4.0095737586554305 -0.0453917406412142 -0.080204532699585024
5.7686913840826772 -0.0042732711788194796 -0.1635095447540284
5.7686913840826772 0.042939308500669654 -0.1276788442230225
5.1173102134283797 0.02485461900749034 -0.13119694343566898
7.6574851639899029 0.27256737922706425 -0.69769121700286874
5.7900191520270132 1.0968325490764601 -0.24544513700485235
5.1020547880133398 1.0182973137096387 -0.24217086738586438
5.7349559238775987 1.053486871204756 -0.23880644096374523
5.7686913840826772 0.73685139207877925 -0.18263015575408945
5.1173102134283797 0.71528876928367435 -0.14084135959625252
5.7686913840826772 0.68625664117851082 -0.13962646282196051
4.5190373514899038 -0.12286045768247197 -0.08943699241638188
4.0095737586554305 -0.073175407220937558 -0.055098933334350689
4.0095727509650008 -0.12286045759021515 -0.047715207672119231
5.1173102134283797 0.02485461900749034 -0.13119694343566898
4.5196278580816998 0.037432847128294151 -0.11166777694702155
5.1173102134283797 -0.031930531653978182 -0.13908678161621105
7.6574851639899029 0.40863742395438973 -0.24912928470611584
4.0095737586554305 0.1789116859821302 -0.083792414474487389
4.5196278580816998 0.1303123983100874 -0.10572051399230964
4.5196278580816998 0.18933759756126231 -0.090862118606567455
7.6574851639899029 0.55850914320030032 -0.61095199596405037
4.5196278580816998 0.60792174726524173 -0.10551129226684579
4.5196278580816998 0.66848759496726817 -0.12768904708862316
4.0095737586554305 0.63311999116935558 -0.0914522473144532
7.6574851639899029 0.55850926916160404 -0.34927037908554087
7.6574851639899029 0.58027254831352049 -0.38998652027130137
4.0095737586554305 0.071853095960996802 -0.081470191879272569
3.4045292170294545 0.027400800800703225 -0.043913065719604578
4.0095737586554305 -0.0453917406412142 -0.080204532699585024
7.6574851639899029 0.23185155294456308 -0.28429415378570566
4.0095737586554305 0.25220378208198374 -0.075429213714599694
3.4045287131842397 0.22338777208366223 -0.049497434158325304
7.6574851639899029 0.12718515702285593 -0.48011114028930674
7.6574851639899029 0.1317103011135084 -0.52605596668243415
3.4010098582037709 0.50398452558555429 -0.049461409225463993
4.0095737586554305 0.46639225622215097 -0.075626154212951727
4.0095737586554305 0.54505679086723147 -0.083587727355957112
5.7971294156988868 -0.011993573317148041 -0.80707072277069103
6.1403558298834584 -0.00055030377826864639 -0.79497072248458867
6.1403558298834584 -0.020631849946595983 -0.76802337991714487
7.6574851639899029 0.52922087278404062 -0.31358251867294318
7.6574851639899029 0.16687532764472787 -0.34927037908554087
2.7050912897833608 1.1274149459270459 -0.076490752601623621
2.0079564390143174 1.0670134777263625 -0.079617049179077193
2.7050912897833608 1.0415772299388868 -0.053596026039123626
7.6574851639899029 0.59367407526054206 -0.52605640754699712
7.6574851639899029 0.58027235937156507 -0.57023590201377883
2.0079564390143174 0.86047246072807138 -0.88576599197387706
2.7019815571173447 0.84300062021293465 -0.81618317285537734
2.7019815571173447 0.8245198296550732 -0.92457013504028329
7.6574851639899029 0.16687507572212046 -0.61095163382530226
5.7971294156988868 0.74867267149009531 -0.83857836837768573
5.7971294156988868 0.68230844709434335 -0.89736255641937268
5.1034443931158799 0.73729786191978286 -0.90896397037506116
7.6574851639899029 0.19616359806098765 -0.31358251867294318
5.1034443931158799 0.16878190942802257 -0.94835433734893815
5.7971294156988868 0.27688429353751964 -0.92930672092437761
5.7971294156988868 0.1630487491992933 -0.92195587116241462
7.6574851639899029 0.14511195402183358 -0.5702354768943787
5.7686913840826772 0.78590884824790785 -0.22082880283355719
6.1403558298834584 0.77000144712486096 -0.21680610263824468
6.1403558298834584 0.81312159128227046 -0.24311740360260017
6.4318998173102155 -0.018668963460542507 -0.72703793346405032
6.7818102421149034 0.0026415084222776138 -0.71851199069976823
6.7818102421149034 -0.013689917811967682 -0.67835152780532848
2.7019815571173447 1.2090165832714064 -0.31837906213760386
2.0079564390143174 1.1093337046245557 -0.32811687860488897
2.0079564390143174 1.1865010002330763 -0.25337717222213757
2.7019815571173447 0.77696175386466804 -0.97547141277313243
2.0079564390143174 0.64795879957237068 -0.99041602867126466
2.0079564390143174 0.78815650175132579 -0.97629715209960943
6.1403548221930278 -0.7980557425495165 -0.90287172595977794
-1.021192231029628 0.18255486476936164 0.024631170959472582
-1.021192231029628 0.20908870786704839 0.0025803221511839737
-1.7252131343499406 0.14282301670112438 -0.048209605789184658
7.7828358073004509 0.75044475809135269 -0.39515657049179087
7.2899824796637303 0.75170972448386975 -0.38360484827041635
7.7828358073004509 0.69254229917564214 -0.41403637496948253
6.7818102421149034 0.32362239273109261 -0.88960157665252704
6.9963656730231065 0.36154486965217414 -0.8871809782791138
6.9963656730231065 0.27878574239768811 -0.8790297703933716
2.0079564390143174 -0.3629872102256792 0.063432353935241576
2.0079564390143174 -0.29768118674240285 0.10972621910095207
1.6732994242438095 -0.32272558465919671 0.13460798522949211
1.6732994242438095 -0.39749797800026115 0.067512177581787028
7.2899824796637303 -0.0072503036113756407 -0.37738150962829597
7.2899824796637303 0.0093254954246503596 -0.32273858285903939
7.0049008109625595 -0.033774990896798911 -0.31695746286392223
2.0079564390143174 0.1813651917461378 0.001416943550109773
2.0079564390143174 0.23622200080909558 -0.022294579086303765
1.6732994242438095 0.21980259847678965 -0.062116615447998097
1.6732994242438095 0.18975012083091561 0.010335192794799731
2.0079564390143174 0.1813651917461378 0.001416943550109773
1.6732994242438095 0.21980259847678965 -0.062116615447998097
0.9820378971442002 0.20879402139701669 0.08058878734588612
1.6732994242438095 0.15178645456352058 0.067512177581787028
0.9820378971442002 0.23769137090720954 0.0012933755111693614
1.6732994242438095 0.21980259847678965 -0.062116615447998097
0.9820378971442002 0.26108562850990125 -0.09014161994934089
0.9820378971442002 0.26979613607444591 -0.19296433601379404
1.6732994242438095 -0.013134215902902426 0.17094920692443846
0.84229844218814531 -0.12286045762096742 0.32026531085968019
1.6732989203985944 -0.12286045762096742 0.18072619735717765
2.0079564390143174 0.16148264081992927 -0.82893760509490977
1.6732994242438095 -0.035314458460428064 -0.85636448234558105
1.6732994242438095 0.088515808296583343 -0.83415319032669077
0.73980322551334099 0.16543864450492685 0.17685565841674794
-0.2314574316827043 0.14482227451362439 -0.73186603023529062
0.33469051127994204 0.12979642931976146 -0.79593665674209602
-0.2314574316827043 0.080613862085722146 -0.80976868793487555
0.9820378971442002 0.023892636785886927 -0.85929575933456426
1.6732994242438095 0.16194258852042978 -0.78356606008529672
0.9820378971442002 0.13519676829376048 -0.79156866512298585
0.9820378971442002 0.20440080602683847 -0.697077124156952
2.0079564390143174 0.16148264081992927 -0.82893760509490977
1.6732994242438095 0.088515808296583343 -0.83415319032669077
1.6732994242438095 0.16194258852042978 -0.78356606008529672
1.6732994242438095 0.2456207924274427 -0.77370706884384166
2.0079564390143174 0.16148264081992927 -0.82893760509490977
1.6732994242438095 0.26278708231010267 -0.84805267379760751
2.0079564390143174 0.16148264081992927 -0.82893760509490977
1.6732994242438095 0.2456207924274427 -0.77370706884384166
-1.6804993907586321 0.16775173490562265 -0.084491877593994263
0.9820378971442002 0.23060733867683236 -0.63665969036102299
0.9820378971442002 0.26188387678184338 -0.58941343177795424
0.33469051127994204 0.27821686965980358 -0.23877384847641003
0.33469051127994204 0.27434015861549199 -0.15434182914733899
0.3339226511725204 0.27311137460746587 -0.28955278629302983
0.3339226511725204 0.26288262395896739 -0.37469239324569709
0.33469051127994204 0.24818407346763441 -0.50269334111213693
1.6732994242438095 0.85629407236137223 -0.72092289005279553
1.6732994242438095 0.85211562101402105 -0.57296975040435794
2.0079564390143174 0.8479372326473219 -0.4424360828590394
0.9820378971442002 0.69739898916282483 -0.073576637840271089
1.3276686606940045 0.92296772069968991 -0.073547225875854591
0.9820378971442002 0.90839544641532721 -0.084266910705566453
0.9820378971442002 0.33756977298774543 -0.1904905819702149
1.6732994242438095 0.34184005012550184 -0.062932214889526425
0.9820378971442002 0.33758816333808722 -0.065793803787231528
7.8621853824957624 1.093110770435713 -0.22332132511138925
8.6453271152838482 1.0542364669231397 -0.43719813949584968
7.7828358073004509 1.1100786397747022 -0.37123428310394296
1.3084782041510363 1.0554833578685743 -0.14563097518920912
1.6732994242438095 1.0270828627208692 -0.089643631935119719
0.33469051127994204 0.26761596633949108 -0.066093024864196895
-0.2314574316827043 0.27312390775718515 -0.039600024719238389
0.33469051127994204 0.25158644573249644 0.027708531570434479
-0.68015452045833924 0.17272093982734507 0.073937463684081953
-0.68015452045833924 0.23030068588294811 0.013884026565551703
-1.6813876698724013 0.26250477153816054 -0.23839228019714365
-1.021192231029628 0.28826820381202523 -0.15398076107025158
-1.021192231029628 0.29965664869346442 -0.24039175844192512
-1.6814204198113663 0.1422360685161573 -0.77746018035888675
-1.021192231029628 0.080560139589689439 -0.7953742080307008
-1.6814204198113663 0.070229439010999845 -0.83175989406585693
0.3744721140631454 0.69739898916282483 -0.09719079238891612
0.67819353648746172 0.890120287685774 -0.096073893508911185
0.37434917583072386 0.87472051061668221 -0.10788100227355969
0.37424387218082106 0.33758816333808722 -0.089407958335876572
-0.1344523643914447 0.33765652883567637 -0.10927847995758065
0.3340153586920514 0.3216977669910413 -0.28838950216293346
-0.2942708069268451 0.36152780189552136 -0.11604587696075447
0.9208630265387312 0.75313862951316657 -0.73119834085464486
0.98397215892398515 0.72579280836143323 -0.45872851619720467
0.33793628215396604 0.76143343328513924 -0.45541897741317761
0.98397215892398515 0.48589314439811532 -0.27678257740020756
0.3362746006354112 0.45750694585838142 -0.45456064559936532
-0.2058930812493544 0.4575068198970777 -0.22491344449996956
1.6732994242438095 0.31208830509223767 -0.92342697322845457
1.0589423115118759 0.36152802232780279 -0.89902310428619403
1.6732994242438095 0.35990598712959115 -0.96538764358520524
1.0074452997931258 0.36152799083747683 -0.77226175735473634
1.0272519590338489 0.36928292446174449 -0.88317792804718021
0.9820378971442002 0.33756977298774543 -0.58941343177795424
0.3340153586920514 0.3216977669910413 -0.37441342044830328
-0.2942708069268451 0.36152780189552136 -0.18747906763076791
0.3362746006354112 0.36152795934715098 -0.45456064559936532
0.68135365367496148 0.8871769499019605 -0.26290044509887706
0.55112830791080192 0.88317308092155278 -0.21765942749023448
0.68032530559146587 0.92258750650443855 -0.2528538659858704
0.68032530559146587 0.96068651819267092 -0.21743861732482919
0.55112830791080192 0.88317308092155278 -0.21765942749023448
0.68032530559146587 0.9398196426586134 -0.18893102357864386
0.68032530559146587 0.92258750650443855 -0.2528538659858704
0.55112830791080192 0.88317308092155278 -0.21765942749023448
0.68032530559146587 0.96068651819267092 -0.21743861732482919
0.68032530559146587 0.9398196426586134 -0.18893102357864386
0.55112830791080192 0.88317308092155278 -0.21765942749023448
0.68032530559146587 0.89556194196739025 -0.17682100936889658
1.6732994242438095 0.86047233476676754 -0.8688760611915588
1.6732994242438095 0.78815650175132579 -0.95940712684631368
1.0590481190069931 0.84789169763603034 -0.89902310428619403
1.6732994242438095 0.86047233476676754 -0.8688760611915588
1.0590481190069931 0.84789169763603034 -0.89902310428619403
1.0273577665289659 0.84789169763603034 -0.88317792804718021
1.0075516111334581 0.84789169763603034 -0.77226175735473634
0.9820378971442002 0.8547793876842481 -0.5137651665115357
1.3084782041510363 0.85344740987815693 -0.54336744271278392
0.33638141582095793 0.85744321733512707 -0.45456064559936532
-0.2942708069268451 0.82351862623252692 -0.19189671949386608
-0.1343470607415419 0.84734641115226572 -0.12775146091461187
0.37434917583072386 0.87472051061668221 -0.10788100227355969
-0.2942708069268451 0.8173259276775342 -0.13451892089843759
0.55112830791080192 0.88317308092155278 -0.21765942749023448
0.68032530559146587 0.89556194196739025 -0.17682100936889658
0.9820378971442002 0.91490424486198252 -0.13295851226806646
0.80393113292300888 0.89092026792564227 -0.28889564617156993
0.68032530559146587 0.85611136549033939 -0.48416289031028759
0.68135365367496148 0.8871769499019605 -0.26290044509887706
-0.2942708069268451 0.67097268552818123 -0.1938293752670289
-0.205387724498866 0.73221009592094244 -0.22928017650604252
-0.2056711374322156 0.67052684549369634 -0.23074460262298596
-0.2058930812493544 0.4575068198970777 -0.22491344449996956
-0.2942708069268451 0.4977284055141431 -0.18747906763076791
-0.20580944294369077 0.49704960004844484 -0.22471571674346932
0.9208630265387312 0.75313862951316657 -0.73119834085464486
1.0076745493658799 0.66229899015464611 -0.77226175735473634
0.9209234879645124 0.66233054346122566 -0.73119771104812636
1.0074452997931258 0.4977287204174024 -0.77226175735473634
0.92069474223697367 0.45750694585838142 -0.73119786849975599
0.92069474223697367 0.49778905588187994 -0.73119783700942997
0.3362746006354112 0.36152795934715098 -0.45456064559936532
0.3362746006354112 0.45750694585838142 -0.45456064559936532
0.33638141582095793 0.85744321733512707 -0.45456064559936532
0.33793628215396604 0.76143343328513924 -0.45541897741317761
-0.2058930812493544 0.4575068198970777 -0.22491344449996956
0.98397215892398515 0.4858930814174634 -0.45805100183486946
0.92069474223697367 0.45750694585838142 -0.73119786849975599
0.98397215892398515 0.7027257037548047 -0.28022938251495372
-0.205387724498866 0.73221009592094244 -0.22928017650604252
1.6732994242438095 0.70594426698722657 -0.047815850753784285
1.6732994242438095 0.93080855993308842 -0.062827604026794534
1.3276686606940045 0.92296772069968991 -0.073547225875854591
1.6732994242438095 0.93080855993308842 -0.062827604026794534
1.3276686606940045 0.92781187753715333 -0.095800746421814034
1.0075516111334581 0.84789169763603034 -0.77226175735473634
2.0079564390143174 1.1865010002330763 -0.25337717222213757
1.6732994242438095 1.1475193776897412 -0.20102576498031627
1.9134653074225207 1.1754945015148146 -0.20186835163116462
5.1173092057379499 -0.41893952049217398 -0.0737445442581178
4.5196278580816998 -0.4350491209980028 -0.090862118606567455
4.5196278580816998 -0.50297460426292595 -0.070410978355407841
5.1173092057379499 -0.51121483530006584 -0.041782367286682179
8.6453271152838482 1.0542364669231397 -0.53871747097015388
8.6453271152838482 0.94968190889396487 -0.53876667460441596
8.0291737943609967 0.81472174070396253 -0.57406317324638378
8.0291737943609967 0.81472174070396253 -0.40371362569808972
7.7828358073004509 0.87247644701041993 -0.38074634542465219
8.6453271152838482 0.94968190889396487 -0.43775429014205935
7.7828358073004509 0.87247644701041993 -0.38074634542465219
8.6453271152838482 0.94968190889396487 -0.43775429014205935
7.8601962015875602 1.0138627200511914 -0.25392548177719121
7.7828358073004509 0.69902678709068111 -0.47987578159332289
7.7828358073004509 0.75044475809135269 -0.39515657049179087
7.7828358073004509 0.69254229917564214 -0.41403637496948253
7.7828358073004509 0.75044475809135269 -0.60464665651321414
7.7828358073004509 0.69254229917564214 -0.54571521970748915
-1.8202564802972061 0.0011279022888166241 0.036362325057983272
-2.1520587080804092 0.03680637858428782 -0.053678593673706178
-2.1520587080804092 -0.03468826545677358 -0.029078099136352609
-2.1520587080804092 0.036806315603635953 -0.85247149080276485
-2.1520587080804092 0.10269607525863475 -0.81252239097595225
-2.1520587080804092 0.10269612249412362 -0.093627536048889279
-2.1520587080804092 0.1604489708713514 -0.14739008777618415
-3.8369473372308001 -0.04738261415443594 -0.7083537154006958
-3.9346111821404679 -0.077868060164071856 -0.69214762853622447
-3.8383837999383195 -0.034465746941186731 -0.69620175607681278
-3.9326154512444722 -0.10231780263862784 -0.70903280427932747
-4.0105890251580458 -0.12286045759021515 -0.67948165262222293
-3.9331162733880265 -0.092898993013717471 -0.70479625328063966
-3.9396924611321671 -0.072833603350736437 -0.64913332336425789
-3.940629109386562 -0.077868056227781132 -0.641207302799225
-3.9414503770867571 -0.084643329748727625 -0.63426009603500377
-3.9421245219842174 -0.092898993013717471 -0.62855861507415778
-3.9323065941277728 -0.1125378294827717 -0.71164162033081058
-3.9355478303948628 -0.072833603350736437 -0.68422163946151737
-3.9376201457635145 -0.068686559667207547 -0.66667746566772468
-3.9386762053338273 -0.069733392572023226 -0.65773355180740367
-3.9426253441277725 -0.10231780067048245 -0.62432219003677381
-3.9429326897088273 -0.11253781373760872 -0.62171334249496468
-3.9365640861932025 -0.069733392572023226 -0.67562141101837159
-3.9337899144402724 -0.084643325812436887 -0.6990948667907716
-3.9430359779778703 -0.12286045768247197 -0.62083240062713629
7.7828358073004509 0.049752681379697981 -0.6090238590526581
7.7828358073004509 0.030548132915876561 -0.54571458990097055
7.8234739469488872 -0.02747140703163321 -0.56359053002357495
7.7828337919195896 -0.1228603207118551 -0.37601596313476571
7.8234739469488872 -0.038084119224168614 -0.45583697999954226
7.7828358073004509 0.030548227386854351 -0.4140362490081787
5.9593675748785744 -4.1950872481342332 -0.26518683170318613
5.943177012744786 -4.1676412877460498 -0.30824059425354011
6.242801669727208 -4.0190895799823778 -0.30948805202484136
6.2861938273199822 -4.0344525763507857 -0.27057394474029545
7.7828337919195896 -0.1228604576517197 -0.60138569155693067
7.8234739469488872 -0.02747140703163321 -0.56359053002357495
7.8612452073248633 -0.1228604278527687 -0.55936955099105845
7.7828358073004509 0.024063550529859704 -0.47987568712234502
7.7828358073004509 0.030548227386854351 -0.4140362490081787
7.8234739469488872 -0.038084119224168614 -0.45583697999954226
6.242801669727208 -4.0190895799823778 -0.30948805202484136
5.943177012744786 -4.1676412877460498 -0.30824059425354011
5.9088218229254492 -4.0859783072467817 -0.31824047321319587
6.2223727616461533 -3.929174118709184 -0.30915132596969613
-3.4274033043328509 -0.17327671357355293 -0.81155689758300786
-3.4287304326287491 -0.21496902730903797 -0.80032571538925179
-3.6568206575433 -0.18788713445148639 -0.7609880947113038
-3.6559137361565814 -0.15814326987228569 -0.76866534170150769
4.0070162403448837 -0.23846585677585777 -0.84966677343368535
4.0070157364996684 -0.12286045755946289 -0.84313460916519167
4.0070162403448837 -0.23846585677585777 -0.84966677343368535
-1.0882164926568252 0.18694855249442879 0.084687694129943716
-1.7252131343499406 0.14282301670112438 -0.048209605789184658
-1.6973540208855851 0.14034927840270822 0.023096710357665889
-1.021192231029628 0.19225190126457042 0.10408277481079091
-1.021192231029628 0.18255486476936164 0.024631170959472582
6.4325024161871687 -1.3808126910968799 -0.28251548570632939
7.3690035477789655 -1.3388223568531052 1.7092159814453125
6.1403548221930278 -1.364185421123125 -0.28365304224014293
7.9833480643805288 -1.3388223568531052 1.7092159814453125
7.78022488139713 -1.2991984576221483 1.7761079837036136
7.7626013834723251 -1.3573668838306445 1.7092159814453125
-1.0882552887383681 0.13970909582176036 0.097407014656066798
-1.6735584190789443 0.099695110178373514 0.022757118682861219
-1.087771597332118 0.12444116874732798 0.20777191570281972
-1.0883205366936906 0.13904945221938914 0.079633055953979376
5.1173092057379499 -0.34499151239357162 -0.10559656806945805
-0.68049058521663985 -0.42711853433571034 0.14096500030517575
-0.68049058521663985 -0.38688293552360703 0.14096500030517575
-0.96180626285946214 -0.39513755763969594 0.092354391860961824
-0.96180626285946214 -0.43663122646293812 0.092354391860961824
7.8621853824957624 -1.338822104930498 -0.22332132511138925
7.7626013834723251 -1.3573668838306445 1.7092159814453125
7.5401325596197859 -1.3573668838306445 1.7092159814453125
7.2834385380133408 -1.3680768696399705 -0.21766547363281255
7.8621853824957624 -1.338822104930498 -0.22332132511138925
-0.19061447895443281 0.17071872192420787 0.20172930004119866
-0.68015452045833924 0.17272093982734507 0.073937463684081953
-0.68049083713924741 0.18140701089896982 0.14096500030517575
-0.96180651478206924 0.19091976600684946 0.092354391860961824
-0.96183976856624931 0.19159167509116953 0.10429766479492174
-1.781786890453456 -0.3365268183132189 0.0034371739196776261
-1.7252126305047255 -0.38853454013786493 -0.048209605789184658
0.33793628215396604 -1.007144893741228 -0.45541894592285159
0.98397215892398515 -0.94843710123024161 -0.28022938251495372
0.98397215892398515 -0.97150414285621822 -0.45872848470687871
-0.19354660618221589 0.13055885734596079 0.22275066711425773
-0.68015452045833924 0.1405696949390394 0.26884412784576417
-0.20566156437313385 0.10339805760421579 0.31791273159027084
-3.1834525359002335 -0.1228604576517197 -0.3227249475479127
-0.074266038097498946 0.16117639740028206 0.21722455577850341
-0.13618886692440338 0.16626684007682627 0.24220381595611565
-0.078415707286952366 0.16121393386878796 0.24869447597503647
0.33469051127994204 0.13537457841911141 0.21385301254272449
-0.12453140018856369 0.16115608614005866 0.15166075248718261
-0.20589282932674685 -0.70321828035316636 -0.22491344449996956
-0.29427055500423749 -0.60723929384193598 -0.18747906763076791
0.80674863536441499 -0.24955724554023917 0.28977196865081783
0.9820378971442002 -0.45450551334343131 0.080588724365234315
0.33469051127994204 0.065412285128019498 0.30060955326080313
0.67767608745181729 0.015840812368772678 0.29987116809844966
0.32608886577212964 0.085460238991163437 0.27237967269897451
0.33469051127994204 -0.026592323093034571 0.36319607219696043
0.74193902537906342 -0.038134952482797455 0.30653848884582507
-0.075138446087001334 0.11308337969817941 0.21755432247161849
-0.079480332225917341 0.11311457086601084 0.24490908687591542
-0.10491544636165939 0.020295087480924782 0.39897834060668935
-0.10982466221248903 -0.035383020772554223 0.4287188121032714
0.98397215892398515 -0.73160460485420398 -0.27678257740020756
0.33627510448062559 -0.70321840631447019 -0.45456061410903936
0.98397215892398515 -0.73160454187355217 -0.45805097034454351
5.7829109037359965 1.0108831054119092 -0.24123547874450688
6.1403558298834584 0.9119767152217847 -0.25644272396087658
6.1315113309820903 0.99138316194572274 -0.23805549116134653
5.1020547880133398 1.0182973137096387 -0.24217086738586438
7.9164726890143173 1.053486871204756 -0.25791036209106455
7.9833480643805288 1.0931110223583205 1.7092159814453125
8.0445451041754499 1.0534871231273635 1.7761082356262203
7.2834385380133408 1.122365787067793 -0.21766547363281255
7.2567790800055274 1.1226542384532909 -0.34757213729858405
6.9963666807135354 1.1262576134685498 -0.33001265920639045
7.9833480643805288 1.0931110223583205 1.7092159814453125
7.7802258890875597 1.0534871231273635 1.7761082356262203
8.0445451041754499 1.0534871231273635 1.7761082356262203
6.1403558298834584 1.1184739606670362 -0.28365304224014293
5.7900191520270132 1.0968325490764601 -0.24544513700485235
7.3690035477789655 1.0931110223583205 1.7092159814453125
7.0067610074957623 0.98026317209281744 -0.28011951276779185
7.2834385380133408 0.98456601022758305 -0.28156151777267463
7.5401335673102166 0.99531831903495604 1.7092159814453125
7.3690035477789655 1.0138630979351027 1.7092159814453125
6.1315113309820903 0.99138316194572274 -0.23805549116134653
6.4702625919684191 0.97229511194267093 -0.25518991283416759
6.7786037711676377 1.1300985515026074 -0.31597175268173222
6.4325034238775975 1.1351013566020947 -0.28251551719665535
8.6453271152838482 1.0542364669231397 -0.43719813949584968
7.8621853824957624 1.093110770435713 -0.22332132511138925
7.9164726890143173 1.053486871204756 -0.25791036209106455
7.9164726890143173 1.053486871204756 -0.25791036209106455
7.8601962015875602 1.0138627200511914 -0.25392548177719121
8.6453271152838482 0.94968190889396487 -0.43775429014205935
8.6453271152838482 1.0542364669231397 -0.43719813949584968
7.9833480643805288 1.0138629719737988 1.7092159814453125
7.7802258890875597 1.0534871231273635 1.7761082356262203
7.7626013834723251 0.99531831903495604 1.7092159814453125
-1.0882162407342177 -0.43266010742149524 0.084687631149291911
-1.6973535170403702 -0.38606075460395983 0.023096710357665889
-1.7252126305047255 -0.38853454013786493 -0.048209605789184658
-0.075138194164393768 -0.35879495037040887 0.21755425949096679
-0.074265786174891379 -0.40688785785637077 0.21722449279785153
-0.12453114826595613 -0.40686760957679924 0.15166075248718261
0.33469051127994204 -0.38108614909134081 0.2138529495620726
-0.10491519443905183 -0.26600665815315416 0.39897821464538574
-0.10982441028988219 -0.21032854202709372 0.4287188121032714
-0.12453114826595613 -0.40686760957679924 0.15166075248718261
-1.0882550368157609 -0.3854206035133379 0.09740695167541491
-1.0877713454095108 -0.3701527394195574 0.2077718527221678
-1.6735579152337294 -0.34540664936027704 0.022757118682861219
6.1393965085943947 1.2607165186504348 -0.2866611241340638
6.4318998173102155 1.2503975167278272 -0.28979611204147349
6.4318998173102155 1.2531107232097607 -0.56110381771087658
6.4318998173102155 1.2531107232097607 -0.56110381771087658
6.1687112308844343 1.2606983802227003 -0.31582220512390147
6.1393965085943947 1.2607165186504348 -0.2866611241340638
0.80393113292300888 -1.1366316024204273 -0.28889564617156993
0.68032530559146587 -1.1018226999851244 -0.48416285881996163
0.9820378971442002 -1.1004907221790332 -0.5137651350212098
1.0023070862921493 -1.1334103310199755 -0.31742764492034919
5.7686913840826772 0.10418553618469063 -0.089545760002136349
5.7686913840826772 0.17931391191520518 -0.050423123779297002
5.1173102134283797 0.17322799705543343 -0.073744481277465912
5.1173102134283797 0.099279941721342274 -0.10559656806945805
5.325728809619787 -4.4848226831623093 -0.25474265573501592
5.3256461790045506 -4.4573757150836961 -0.19270957927703866
5.2483109769781837 -4.4628782086750052 -0.19756141975402838
5.2365995988043563 -4.4894112015338914 -0.25327353755950938
5.1034443931158799 -1.5072661256214159 -0.39600268405914313
4.5196278580816998 -1.0485628598209398 -0.61952315883636477
5.1034443931158799 -1.0483290126606006 -0.61979958091735854
-2.4738706929436902 -0.48300189653358633 -0.41871246793746952
-2.4738706929436902 -0.46284134901008783 -0.34527831897735606
-2.8393131541863661 -0.43477150228462397 -0.42234840394973766
-2.8318824449578508 -0.45327905961952381 -0.48523897772789015
-2.1520582042351943 -0.48877599418602163 -0.61851033548355117
-3.8348931602898819 -0.16463299699030096 -0.72573700511932382
-3.6602755241814835 -0.23932614098987753 -0.73174318647384651
-3.6626914619866593 -0.2590445407196062 -0.71129922601699835
-3.8383832960931046 -0.2112458237310427 -0.69620169309616098
-3.8369468333855847 -0.19832895651779348 -0.708353652420044
3.4010098582037709 -1.0693446484943407 -0.57185636269569406
3.4010098582037709 -1.4556685967823046 -0.36178214687347421
2.9421887556036723 -1.4568530109210986 -0.3352931145095826
4.5196278580816998 -1.1222159610172289 -0.18717672901153573
4.5196278580816998 -0.91419905542335667 -0.12768904708862316
0.9820378971442002 -0.4834028313632982 0.0012933125305174698
0.33469051127994204 -0.49729796916923691 0.027708468589782587
7.7828358073004509 -0.84589225580177474 -0.71851136089324963
7.7828358073004509 -0.79475146264991936 -0.76048150983810436
-1.7619968581048233 -0.24001961307487663 0.069360155868530185
-1.8202559764519914 -0.24683947296104605 0.036362325057983272
-1.781786890453456 -0.3365268183132189 0.0034371739196776261
-1.781786890453456 -0.3365268183132189 0.0034371739196776261
-1.728542543529628 -0.32520618784866512 0.042950982971191334
-1.0211919791070208 -0.53397966426811394 -0.15398076107025158
-1.0211919791070208 -0.54536814063987904 -0.24039175844192512
-0.68015426853573169 -0.54250919692955191 -0.24481328361511237
7.2899814719733023 -0.68186317880592517 -0.097308818130493233
7.7847504191168566 -0.67309614610634028 -0.14887857250213635
-2.4738706929436902 -0.27110717773399529 -0.85673833549499512
-2.4738706929436902 -0.33235723149261648 -0.82056410699844373
-2.7875576698724016 -0.25875697106323414 -0.86037313785552993
2.7050907859381459 -1.3731262804218309 -0.076490752601623621
3.4010098582037709 -1.3933125870319383 -0.12085974010467541
3.4010098582037709 -1.2835175349231738 -0.075345575408935619
2.7050907859381459 -1.2872885644336718 -0.053596026039123626
2.7050912897833608 -0.28613579407653983 0.038036728668212796
2.7050912897833608 -0.23763091440162834 0.063579791641235256
1.6732994242438095 -1.1020055328174609 -0.72092282707214361
1.0075516111334581 -1.0936030321308152 -0.77226169437408454
1.0273577665289659 -1.0936030321308152 -0.88317786506652851
1.6732994242438095 -1.1061837952228564 -0.86887599821090711
-1.6814199159661514 -0.44387636320076157 -0.71098892034530647
-2.1520582042351943 -0.45355718217811758 -0.69324994739532475
-2.1520582042351943 -0.40616049430809198 -0.75875983924865731
-1.6814199159661514 -0.38794752897224599 -0.77746011737823495
-2.4738706929436902 -0.43010252613029654 -0.27760088500976571
-2.8461614183465227 -0.40471672584495716 -0.36438809730529792
-2.8607512642327531 -0.2587570025535601 -0.24091279737472543
-0.074265786174891379 -0.40688785785637077 0.21722449279785153
-0.075138194164393768 -0.35879495037040887 0.21755425949096679
-0.079480080303309789 -0.35882611004791432 0.24490902389526351
-0.078415455364344799 -0.40692545730552843 0.24869441299438474
-3.4502748540154675 -0.35216672486267264 -0.61798469896316532
-3.1519511253777726 -0.41136508941612415 -0.58933807542800909
-3.1580970293084367 -0.40600354652366805 -0.53732443342208869
-0.68015426853573169 -0.52499805648765741 -0.41169198318481459
-0.68015426853573169 -0.53943863822899041 -0.32920899459838876
2.0079564390143174 0.11727565529861275 0.063432416915893464
1.6732994242438095 0.077014013986967264 0.13460798522949211
2.7019815571173447 -1.0226732143207569 -0.97547134979248051
3.4045282093390243 -0.1228604576517197 0.031424830894470103
3.9515564860113881 -1.4804624419208543 -0.39081975429534921
0.33469051127994204 0.13537457841911141 0.21385301254272449
-3.9365635823479872 -0.17597817416391545 -0.67562134803771978
-3.9376196419183001 -0.17702500706873114 -0.66667740268707276
2.7019815571173447 -1.0702313530918139 -0.92457007205963138
2.0079559351691025 -1.1061839211841602 -0.88576592899322526
2.0079564390143174 -1.0338679622074145 -0.97629708911895763
2.7019815571173447 -1.0226732143207569 -0.97547134979248051
6.4318998173102155 0.0079918013957959895 -0.75898502656936651
6.4318998173102155 0.059171500845335179 -0.80485969251632705
6.7818102421149034 0.057031355314634505 -0.77633984903335584
3.4045282093390243 -0.1228604576517197 0.031424830894470103
5.1034443931158799 0.11081210845031562 -0.92150914939880391
5.7971294156988868 0.10973438353576487 -0.89710584728240972
5.7971294156988868 0.053770532064817605 -0.85160648303985609
2.0079559351691025 -0.12286045759021515 -0.8368193187713624
2.7019815571173447 0.082536094561002901 -0.83436181373596208
0.71878280315005971 0.073257611732862646 0.2568761035156249
0.80674863536441499 0.0038456827405912259 0.28977203163146958
7.8234739469488872 -0.21824015576801475 -0.56359048278808599
1.6732994242438095 0.84793710668601818 -0.40009951248168951
0.9208630265387312 0.75313862951316657 -0.73119834085464486
0.98397215892398515 0.71924527681388684 -0.67641062156677256
0.98397215892398515 0.72579280836143323 -0.45872851619720467
-0.2942708069268451 0.82351862623252692 -0.19189671949386608
-0.2942708069268451 0.36152780189552136 -0.18747906763076791
1.0075516111334581 0.84789169763603034 -0.77226175735473634
1.0074452997931258 0.36152799083747683 -0.77226175735473634
0.98397215892398515 0.48589327035941904 -0.6764102436828614
7.7828358073004509 0.75044475809135269 -0.60464665651321414
7.7828358073004509 1.1100786397747022 -0.60428909960746779
-1.7817873942986711 0.090815247640989485 0.0034371739196776261
-1.6812239201775772 0.22109600063361945 -0.15552114185333263
-2.1520587080804092 0.20784562725105107 -0.21289991664886482
-3.9331157695428112 -0.15281257372222121 -0.70479619029998786
-3.9337894105950579 -0.1610682409235018 -0.69909480381011968
-3.8357688432732808 -0.063121821510412054 -0.71832657566070568
5.0012494681891226 -4.3540567114826212 -0.24939427579879772
5.0283079716070906 -4.3286299107929249 -0.30574542678833017
7.7828337919195896 -0.1228603207118551 -0.37601596313476571
7.8612452073248633 -0.12286035217142875 -0.43482630389213567
7.8234739469488872 -0.038084119224168614 -0.45583697999954226
7.7828337919195896 -0.1228604576517197 -0.60138569155693067
7.7828358073004509 0.049752681379697981 -0.6090238590526581
5.7686903763922466 -0.61211078428230459 -0.0038035856628419232
5.7686903763922466 -0.51378740598640615 -0.022416257705688603
7.2899814719733023 -0.46304102916679551 -0.12135911369323739
7.7847504191168566 -0.47810811094246081 -0.16808326267242443
-1.0881489773980362 0.18772963853874033 0.10393514816284172
-1.0211919791070208 -0.51452648393593003 -0.48715875395774855
-1.6814199159661514 -0.52706108221016101 -0.48827513324737559
-0.16034673344051653 -0.30364495062790092 0.42983432540893551
-0.10272422352230348 -0.2951955923362749 0.42594136535644522
-0.19503420917904205 0.1691769870571119 0.23514966804504386
-0.68015452045833924 0.17272093982734507 0.073937463684081953
6.7818102421149034 -1.445099939555742 -0.61723330829620371
6.9963656730231065 -1.4052450272937793 -0.61498319854736339
6.9963656730231065 -1.411626856746294 -0.33001924068450939
6.7818102421149034 -1.4490644456287403 -0.32231399879455574
-0.19085985157406157 0.1318966766075117 0.20189613578796375
-0.68049083713924741 0.14117141208686654 0.14096500030517575
-0.68015452045833924 0.15006421714820689 0.16766218372344965
-3.8357683394280655 -0.18258973735294515 -0.71832651268005387
0.32608886577212964 0.12792546309509104 0.27205519638061521
1.6732994242438095 -1.0978270814701099 -0.57296970316886908
1.6732994242438095 -1.0936486301227588 -0.40009948099136361
7.7626013834723251 1.111655801258467 1.7092159814453125
-0.96180626285946214 -0.43663122646293812 0.092354391860961824
5.7829109037359965 1.0108831054119092 -0.24123547874450688
8.0445451041754499 1.0534871231273635 1.7761082356262203
7.9164726890143173 1.053486871204756 -0.25791036209106455
8.0445451041754499 1.0534871231273635 1.7761082356262203
7.9833480643805288 1.0138629719737988 1.7092159814453125
7.9164716813238876 -1.299198205699541 -0.25791036209106455
8.0445451041754499 -1.2991984576221483 1.7761079837036136
7.9833480643805288 -1.3388223568531052 1.7092159814453125
6.9963656730231065 -1.3719691998859422 -0.33001265920639045
6.7786037711676377 -1.3758098859973924 -0.31597175268173222
-3.9355473265496475 -0.17287795944891149 -0.68422157648086557
5.7900191520270132 -1.3425440095325487 -0.24544513700485235
5.7829098960455676 -1.2565944399066942 -0.24123547874450688
6.1315103232916615 -1.2370944964405077 -0.23805549116134653
6.1403558298834584 -1.1576881756778734 -0.25644272396087658
1.6732994242438095 -0.23257733115158255 0.17094920692443846
8.6453261075934176 -1.19539324338875 -0.43775425865173351
7.9164716813238876 -1.299198205699541 -0.25791036209106455
8.6453261075934176 -1.2999478014179247 -0.43719810800552378
5.1020547880133398 -1.2640086482044237 -0.24217086738586438
5.7349559238775987 -1.299198205699541 -0.23880644096374523
-3.6556068944207412 -0.12286045762096742 -0.7712576253318788
8.0445451041754499 -1.2991984576221483 1.7761079837036136
7.7828337919195896 -0.1228603207118551 -0.37601596313476571
7.7828358073004509 -0.27625978231392079 -0.41403621751785286
7.8234739469488872 -0.20762744357547935 -0.45583694850921641
-0.078415455364344799 -0.40692545730552843 0.24869441299438474
-0.13618861500179583 -0.41197836351356676 0.24220375297546376
-0.19061422703182526 -0.41643024536094841 0.20172923706054677
-0.68049058521663985 -0.42711853433571034 0.14096500030517575
-0.68015426853573169 -0.41843246326408556 0.073937463684081953
-3.9406286055413466 -0.16784350657186681 -0.64120723981857308
-3.9346106782952535 -0.16784351050815757 -0.69214759704589857
0.68032530559146587 -1.1682987150379198 -0.2528538659858704
0.68032530559146587 -1.2063978526874561 -0.21743861732482919
0.55112830791080192 -1.1288845413776414 -0.21765942749023448
5.8253004093512315 1.262913913593672 -0.35735813396453869
5.9688197111090435 2.5117216121868116 -0.3098861212348939
6.1433265012701757 1.2606799898723586 -0.34498331760406503
5.8253004093512315 1.260850163593672 -0.24427775913238531
6.1393965085943947 1.2607165186504348 -0.2866611241340638
5.9701256779059184 2.5117216121868116 -0.24005698478698737
0.33469051127994204 -0.52392836160621825 -0.23877384847641003
7.6574851639899029 -0.3728966962047594 -0.48011114028930674
7.5314513065680284 -0.60845620599708727 -0.48011112454414373
7.6574851639899029 -0.37742184029541193 -0.5260559194469453
7.6574851639899029 -0.47756304489097767 -0.28429415378570566
7.6574851639899029 -0.51827909160576036 -0.26253096910476686
4.0095732548102161 -0.17253614770612891 -0.055098933334350689
5.8253004093512315 1.262913913593672 -0.48830852873802189
5.1034443931158799 1.2615547911266309 -0.39600268405914313
5.8253004093512315 1.262913913593672 -0.35735813396453869
7.6574851639899029 -0.77493245920143294 -0.31358248718261728
7.6574851639899029 -0.80422085557899647 -0.34927037908554087
3.4045287131842397 -0.27311232423744375 -0.043913065719604578
1.6732994242438095 -1.353690577220537 -0.14345373405456555
1.6732994242438095 -1.2727939452930468 -0.089643631935119719
7.6574851639899029 -0.80422072961769275 -0.61095194872856151
7.6574851639899029 -0.77493239622078114 -0.646639856376648
0.9820378971442002 -0.94311032365760983 -0.073576700820922977
0.9820378971442002 -1.154106906871416 -0.084266910705566453
1.3276686606940045 -1.1686789922138232 -0.073547225875854591
0.9820378971442002 -0.50759533723793204 -0.58941341603279118
5.1034443931158799 1.2615547911266309 -0.39600268405914313
5.3302704703863881 2.5117213602642043 -0.32345659378051766
5.7686903763922466 -0.24143827587566549 -0.1635095447540284
5.1173092057379499 -0.27056620542488269 -0.13119694343566898
5.7686903763922466 -0.28865089491806206 -0.1276788442230225
7.6574851639899029 -0.37742193476638963 -0.43416593601226816
3.4045287131842397 -0.18709655407390768 0.0078750425720214307
3.4045287131842397 -0.21797436954460317 -0.0063102785873413803
4.0095732548102161 -0.17253614770612891 -0.055098933334350689
4.5190373514899038 -0.12286045768247197 -0.08943699241638188
4.0095732548102161 -0.20031982215843375 -0.080204532699585024
7.6574851639899029 -0.69852830015144518 -0.69769127998352054
7.6574851639899029 -0.65602801156959711 -0.71109302736282365
7.6574851639899029 -0.73924447282753158 -0.67592815828323372
2.0079564390143174 -0.40719416425666988 -0.82893751062393184
1.6732994242438095 -0.40765414344749623 -0.78356602859497071
1.6732994242438095 -0.33422736322364976 -0.83415312734603897
-0.23145717976009675 -0.39053379795036486 -0.73186596725463871
0.9820378971442002 -0.47631883062324698 -0.63665962738037118
1.6732994242438095 -0.40765414344749623 -0.78356602859497071
5.3325327354010366 2.5117213602642043 -0.20775253946304331
3.3811644028815047 2.5122861707500443 -0.2226907628250123
3.4577992600592391 2.5122866745952592 -0.27985908777236951
2.0079564390143174 1.1865010002330763 -0.25337717222213757
2.7019815571173447 1.2090165832714064 -0.12582677219390875
2.9451679923590444 1.2111416764263134 -0.12407716968536384
3.4596418220099232 2.5122866745952592 -0.16807916893005384
3.4577992600592391 2.5122866745952592 -0.27985908777236951
2.9421887556036723 1.2111416764263134 -0.3352931145095826
2.7019815571173447 1.2090165832714064 -0.31837906213760386
6.0242336155279892 2.5117216121868116 -0.27267863216400157
5.9701256779059184 2.5117216121868116 -0.24005698478698737
6.1393965085943947 1.2607165186504348 -0.2866611241340638
6.1687112308844343 1.2606983802227003 -0.31582220512390147
4.0658799729498636 2.5122861707500443 -0.30261598117828381
5.0283079716070906 4.082918324375532 -0.30574542678833017
5.9105973734625596 3.8402677285198195 -0.21049607112884527
5.4434905363043553 4.0774153269390094 -0.18234510532379156
5.4939355192145118 4.1453223253826126 -0.19775319583892828
5.3977947983893166 4.1841053069499949 -0.18729166870117195
3.9515569898566021 1.2347511074260695 -0.39081978578567511
4.5235900968512306 1.2289937941173537 -0.39561821866989144
4.5196278580816998 0.87650450056114015 -0.18717672901153573
4.068142237964512 2.5122861707500443 -0.16537534656524666
3.9465306299933216 0.88319065252342055 -0.15114565553665169
5.1862513541754502 4.189607800541304 -0.30834879501342782
5.2464689188727158 4.2171666222576123 -0.30934137008667001
5.3236015751227157 4.2116641286663032 -0.31673951831817637
5.4410398331793557 4.0774153269390094 -0.33098186845779426
5.188093412280919 4.189607800541304 -0.19656890766143809
5.3955325333746682 4.1841053069499949 -0.32453230331420907
5.4919654844244725 4.1453223253826126 -0.31724493804931647
5.3256461790045506 4.2116641286663032 -0.19270957927703866
6.7818102421149034 1.2033531111339553 -0.32231399879455574
6.4318998173102155 1.2503975167278272 -0.28979611204147349
6.4325034238775975 1.1351013566020947 -0.28251551719665535
6.7786037711676377 1.1300985515026074 -0.31597175268173222
4.5196278580816998 -0.93837121854744132 -0.96311309734344497
5.1034443931158799 -0.91166609956703359 -0.93912131080627459
5.1034443931158799 -0.98300919641456785 -0.90896390739440924
4.5196278580816998 -0.99402501626930406 -0.91656183025360116
-1.0211919791070208 -0.53357935924492061 -0.40672828907012942
-1.0211919791070208 -0.54228435600242786 -0.32478743793487558
0.33469051127994204 0.2204402775768263 -0.60248314516067514
0.33469051127994204 0.17272714342155282 -0.70260896673202522
-0.2314574316827043 0.19339566139259165 -0.65236923776626599
-0.2314574316827043 0.22984461149253668 -0.5737620784950257
6.4318998173102155 0.77621518121757338 -0.25013984075546269
6.4318998173102155 0.81488246732749769 -0.28604092216491706
5.9446049100836529 3.9219302051738727 -0.22162292587280283
7.6574851639899029 -0.60840345970115839 -0.71561818719863901
0.33401586253726651 -0.56740922744713007 -0.28838947067260751
0.33401586253726651 -0.56740922744713007 -0.37441342044830328
-0.29427055500423749 -0.60723929384193598 -0.18747906763076791
-0.29427055500423749 -0.60723929384193598 -0.11604587696075447
-0.9621045392266494 0.12584064606704537 0.34442997928619379
-0.96224536396419846 0.025690482473753152 0.43291231582641587
-0.96224536396419846 0.0060484940198880918 0.39423501579284659
-0.9621045392266494 0.092953739929578949 0.31745454734802231
-2.4738711967889055 0.18439100269355599 -0.27760088500976571
-2.4738711967889055 0.14033186425247018 -0.2182812039756776
-3.8503471007195693 -0.04738261415443594 -0.59494573096275338
-3.8515260985223039 -0.063121833319284268 -0.58497276048660285
-3.6848022053948624 -0.030412335805513207 -0.52417253028869637
-3.6828200783196672 -0.0063854139371889301 -0.54095056019783028
5.9446049100836529 -4.1676412877460498 -0.22162292587280283
5.493934511524083 -4.3910339118000046 -0.19775319583892828
5.5084261075934178 -4.4162695032306685 -0.25775404411315922
5.9593675748785744 -4.1950872481342332 -0.26518683170318613
0.37424387218082106 -0.58329965528450189 -0.089407958335876572
-0.13445211246883712 -0.58336802078209093 -0.10927847995758065
2.0079564390143174 -0.40719416425666988 -0.82893751062393184
6.4318998173102155 -0.2270426150842684 -0.72703787048339852
6.7818102421149034 -0.23202166073284325 -0.67835146482467656
6.7818102421149034 -0.24835308696708852 -0.71851192771911632
6.1403558298834584 1.1184739606670362 -0.28365304224014293
2.0079564390143174 1.1511572661022169 -0.14016620700836188
6.7818112498053331 1.199388605060957 -0.61723337127685551
6.4318998173102155 0.77424476854362312 -0.61862379512786869
6.4318998173102155 1.2531107232097607 -0.56110381771087658
0.75653189433658308 -0.020850148758508515 0.31317318561553942
0.71878280315005971 0.073257611732862646 0.2568761035156249
0.69226946025455138 0.044122242594144996 0.30514749816894515
0.75653189433658308 -0.020850148758508515 0.31317318561553942
5.7686903763922466 -0.3498970911117571 -0.089545760002136349
-0.10272422352230348 -0.2951955923362749 0.42594136535644522
-0.092189072002528238 -0.37102949307403743 0.35128428958892804
-0.093891564983485706 -0.32900555865249803 0.334083643760681
-0.093891564983485706 -0.32900555865249803 0.334083643760681
-0.10491519443905183 -0.26600665815315416 0.39897821464538574
-0.96190753574764565 0.18192716810264414 0.22819647811889632
-0.96190753574764565 0.14162279441871467 0.21659304878234856
7.0049008109625595 -0.21193657977543051 -0.31695743137359628
6.7631498307379498 -0.20041945754966908 -0.2683001227760316
6.7631498307379498 -0.24835350421390709 -0.21347625259399425
-3.8489111418572648 -0.034465746941186731 -0.6070976587963105
-3.8472736449090226 -0.024867684540368865 -0.62096176288604743
7.6574851639899029 -0.41258653617820912 -0.61095157084465035
7.6574851639899029 -0.39082344596824825 -0.5702354454040528
7.7828358073004509 -0.93825375963173085 -0.54571517247200019
7.7854144871100202 -0.83938566167793438 -0.52605636031150826
7.7854144871100202 -0.84391088449440177 -0.48011120326995854
7.7828358073004509 -0.94473831052742185 -0.47987575010299693
1.0023070862921493 -1.1334103310199755 -0.31742764492034919
1.3132758182867783 -1.1209300220676439 -0.35444376728057869
1.3084782041510363 -1.2664014091297169 -0.30242247312545789
0.9820378971442002 -1.2220495523639696 -0.28294217962265023
1.0023070862921493 -1.1334103310199755 -0.31742764492034919
0.98397215892398515 -0.76335296251259033 -0.45805097034454351
0.98397215892398515 -0.76340057588539301 -0.6764101807022096
7.7854144871100202 -0.39082357192955192 -0.38998645729064946
7.7847504191168566 -0.2954643622680681 -0.3507269956016541
-1.6814204198113663 0.29249077310600108 -0.41262045969963079
-1.6814204198113663 0.28134962175407235 -0.48827514899253849
-2.1520587080804092 0.27207505947151006 -0.45307502649307257
-0.19061447895443281 0.17071872192420787 0.20172930004119866
-0.19085985157406157 0.1318966766075117 0.20189613578796375
-0.19354660618221589 0.13055885734596079 0.22275066711425773
-0.19503420917904205 0.1691769870571119 0.23514966804504386
2.0079564390143174 1.0670134777263625 -0.079617049179077193
2.0079564390143174 1.1511572661022169 -0.14016620700836188
3.4010098582037709 0.20702628046073737 -0.96605076686859137
3.4010098582037709 0.13471051042594734 -0.93656039154052739
2.7019815571173447 0.18357597007789439 -0.92793097156524673
2.7019815571173447 0.27951540473975955 -0.97076430183410656
5.1034443931158799 -0.0062850542684572495 -0.8422244442749024
-1.7619973619500382 -0.0056919418521898359 0.069360218849182073
-1.7356654033318741 -0.023640482921220608 0.065478910217285025
-1.7035241093865616 0.048301811848066492 0.041091542205810419
-1.7285430473748427 0.079494617176435647 0.042950982971191334
5.1034443931158799 -0.0062850542684572495 -0.8422244442749024
5.1034433854254502 -0.1228604576517197 -0.83029235040664684
4.5196278580816998 -0.1228604576517197 -0.83658238555908215
4.5196278580816998 -0.0074332072969453952 -0.8540308917427063
-2.4738711967889055 0.24409773132362195 -0.49508148378372202
-2.8241554747430069 0.21381675987281629 -0.55064290463447585
-2.8318829488030652 0.20756750469245738 -0.48523899347305305
-2.4738711967889055 0.23729034160651982 -0.41871249942779548
0.9820378971442002 0.26188387678184338 -0.58941343177795424
0.9820378971442002 0.33756977298774543 -0.58941343177795424
2.0079564390143174 0.86047246072807138 -0.88576599197387706
2.0079564390143174 0.78815650175132579 -0.97629715209960943
-0.2942708069268451 0.8173259276775342 -0.13451892089843759
-0.2942708069268451 0.82351862623252692 -0.19189671949386608
-0.2942708069268451 0.67097268552818123 -0.1938293752670289
-0.2942708069268451 0.6733172032741529 -0.12292178962707526
0.75653189433658308 -0.020850148758508515 0.31317318561553942
0.69226946025455138 0.044122242594144996 0.30514749816894515
0.67767608745181729 0.015840812368772678 0.29987116809844966
0.74193902537906342 -0.038134952482797455 0.30653848884582507
-2.1520587080804092 0.26475207864799327 -0.36873675386428845
-2.4738711967889055 0.21712988855399915 -0.34527831897735606
-2.1520587080804092 0.24306447074928111 -0.28763962303161628
6.4318998173102155 -0.25370336419544393 -0.7589849320983888
6.112183828540684 1.2605989967540723 -0.50968663396835334
6.1433265012701757 1.2606799898723586 -0.34498331760406503
6.112183828540684 1.2605989967540723 -0.50968663396835334
6.9963656730231065 1.165915522251509 -0.33001927217483529
6.9963666807135354 1.1262576134685498 -0.33001265920639045
5.3977947983893166 -4.4298168933673878 -0.18729166870117195
5.493934511524083 -4.3910339118000046 -0.19775319583892828
6.7818102421149034 -0.56933385318718133 -0.88960151367187512
3.4045292170294545 0.027400800800703225 -0.043913065719604578
2.7050912897833608 0.10930110814132518 -0.019435257492065483
2.7050912897833608 0.040424270639799281 0.038036728668212796
-3.4632307298699603 -0.31471117074928456 -0.50833484874725354
-3.1694526927605846 -0.36433956227264575 -0.44121559655189524
-3.1742261223260151 -0.32963818355522329 -0.40081396499633798
-3.4667647002068742 -0.28707168656311211 -0.47842688020706187
6.1403558298834584 -0.011267469381906332 -0.16008906555175789
5.7686913840826772 -0.0042732711788194796 -0.1635095447540284
5.7686913840826772 -0.047629608525850117 -0.17142602375030525
5.7686913840826772 -0.047629608525850117 -0.17142602375030525
6.1403558298834584 -0.055917082924463103 -0.19255842571258552
6.1403558298834584 -0.011267469381906332 -0.16008906555175789
6.4318998173102155 -0.87478714906654531 -0.86019613073348999
6.4318998173102155 -0.94566947946510493 -0.79356427005767827
-1.6814204198113663 -0.014843014821626494 -0.86902280611038207
-2.1520587080804092 -0.034688359927751378 -0.87707204832077046
6.7631498307379498 0.0026419492868406066 -0.21347625259399425
6.4318998173102155 -0.0020755613323228976 -0.17259056749343879
6.4318998173102155 -0.0519154733749407 -0.22502923442840586
6.4318998173102155 -0.0519154733749407 -0.22502923442840586
6.7631498307379498 -0.045292113122560332 -0.2683001227760316
0.81775211101138734 1.0075674260143261 -0.21334944105148324
0.81775211101138734 0.97055835748710462 -0.16931566806793216
0.9820378971442002 1.0038122676280958 -0.15278330993652353
0.9820378971442002 1.0437646739391309 -0.21057523780822759
-0.092189323925135805 0.1253179538921339 0.35128435256957996
-0.093891816906092551 0.083294035215757567 0.33408370674133286
-0.079480332225917341 0.11311457086601084 0.24490908687591542
-0.078415707286952366 0.16121393386878796 0.24869447597503647
7.6574851639899029 -0.69852830015144518 -0.69769127998352054
7.7854144871100202 -0.69852830015144518 -0.69769127998352054
3.4010098582037709 -1.0418112709613818 -0.92236883529663105
4.007016744190099 -1.0146565960880296 -0.92040327213287354
4.007016744190099 -1.0522830639453906 -0.8125825060081483
3.4010098582037709 -1.073080282878496 -0.81323914228439342
6.1403548221930278 -0.18979447200260338 -0.19255842571258552
6.1403548221930278 -0.1228604576517197 -0.20289663673400885
5.7686903763922466 -0.12286045759021515 -0.17305829330444342
5.7686903763922466 -0.19808195427379782 -0.17142602375030525
-1.082313442119716 -0.12286023786523589 0.43227117279052724
-1.0832619307366593 0.011093661480329694 0.40297332931518548
-1.0835604590264543 -0.0094645931144731795 0.37355229568481446
-1.0826484991875871 -0.12311938310488336 0.40060702026367173
7.0067610074957623 0.98026317209281744 -0.28011951276779185
6.7530910648688094 0.97663271539726082 -0.27203304899215702
6.7673317460211528 0.89612599668540771 -0.34287951190948496
7.0049008109625595 0.88467617715873537 -0.35782173454284677
5.4919654844244725 -4.3910339118000046 -0.31724493804931647
6.1403558298834584 0.77897612703361341 -0.60189205599784867
6.112183828540684 1.2605989967540723 -0.50968663396835334
5.1034443931158799 -0.23942650853119071 -0.84222438129425048
4.5196278580816998 -0.23827833975753956 -0.85403082876205461
7.2899814719733023 -0.23846125131569085 -0.37738150962829597
7.2899804642828716 -0.12286045768247197 -0.35909359731674201
7.0303208097418555 -0.12286032068110282 -0.32102642234802253
7.0049008109625595 -0.21193657977543051 -0.31695743137359628
1.3276686606940045 0.92781187753715333 -0.095800746421814034
1.0590481190069931 -1.0936030321308152 -0.89902304130554211
1.0273577665289659 -1.0936030321308152 -0.88317786506652851
1.0274807047613876 -0.9080103876300829 -0.88317786506652851
1.0591710572394148 -0.9080103876300829 -0.89902304130554211
5.797128408008458 -0.92801997053108387 -0.89736249343872077
5.797128408008458 -0.85152329290352036 -0.91520094432830823
6.1403558298834584 0.10777332348861521 -0.075346205215454168
6.1403558298834584 0.18851192121543711 -0.035116243171691985
8.6453271152838482 1.0542364669231397 -0.53871747097015388
7.7828358073004509 1.1100786397747022 -0.60428909960746779
7.2567780723150985 -0.98362880006752185 -0.58375723390579226
7.7828358073004509 -0.93825375963173085 -0.54571517247200019
7.7828358073004509 -0.9961562185474413 -0.60464659353256234
7.7828358073004509 -0.9961562185474413 -0.60464659353256234
7.2567780723150985 -0.98362880006752185 -0.58375723390579226
3.4010098582037709 0.70241917692222422 -0.04927819850921638
3.9465306299933216 0.88319065252342055 -0.15114565553665169
3.4010098582037709 0.8862151093868238 -0.06512589397430428
-2.1520587080804092 0.20784562725105107 -0.69325001037597656
-2.4738711967889055 0.18439100269355599 -0.71256201957702647
-2.4738711967889055 0.21712988855399915 -0.64488468008041389
-2.1520587080804092 0.24306447074928111 -0.61851039846420297
6.4318998173102155 0.77424476854362312 -0.61862379512786869
6.7818102421149034 0.77109964075126469 -0.61547882478713989
6.7818102421149034 0.72992610258140389 -0.69943256904602058
6.4318998173102155 0.74879642847099126 -0.7088676690101624
-1.021192231029628 -0.0063160328765886576 -0.84751255172729489
3.4010098582037709 0.79609981050529299 -0.92236889827728274
3.4010098582037709 0.74047277956046875 -0.96495647804260265
2.7019815571173447 0.77696175386466804 -0.97547141277313243
2.7019815571173447 0.8245198296550732 -0.92457013504028329
5.797128408008458 -0.99438413194618402 -0.83857830539703382
6.4318998173102155 -0.0519154733749407 -0.22502923442840586
6.1403558298834584 -0.055917082924463103 -0.19255842571258552
6.4318998173102155 -0.1228603207118551 -0.23812048719406134
5.1173092057379499 -0.1228604576517197 -0.13712858718872081
5.1173092057379499 -0.21378103114566976 -0.13908678161621105
5.7686903763922466 -0.19808195427379782 -0.17142602375030525
6.4318998173102155 -0.8675276842304247 -0.087033146896362434
6.1403548221930278 -0.86338374628029035 -0.079410472640991256
0.9209234879645124 -0.90804194093666246 -0.73119764806747445
0.92069474223697367 -0.74350057931862046 -0.73119777402877817
1.0074452997931258 -0.74344018087349117 -0.77226169437408454
1.0076745493658799 -0.90801032464943099 -0.77226169437408454
6.7631498307379498 -0.20041945754966908 -0.2683001227760316
6.763148823047521 -0.12286045762096742 -0.27930970754623419
6.4318998173102155 -0.19379609729728869 -0.22502923442840586
-0.68015426853573169 -0.44265954551658798 -0.64823235364913956
-1.0211919791070208 -0.39252760793647939 -0.72031597700119021
-0.68015426853573169 -0.39301281087837397 -0.7277291776084901
7.7854144871100202 -0.6985284261127489 -0.26253096910476686
7.7847504191168566 -0.73640536802253898 -0.16808326267242443
7.7847504191168566 -0.79475158861122308 -0.19926989589691166
7.7854144871100202 -0.7392445358081835 -0.28429415378570566
7.2567780723150985 -0.5328801795383471 -0.84254725160598765
7.2567780723150985 -0.46136224840126216 -0.82085230646133434
7.7828358073004509 -0.4781077645488756 -0.79166789113998426
7.7828358073004509 -0.54141695497474851 -0.81087258131027229
0.69226946025455138 -0.28983381326637442 0.30514743518829346
0.32608886577212964 -0.37363701802215749 0.27205513339996334
0.69226946025455138 -0.28983381326637442 0.30514743518829346
7.6574851639899029 -0.6985284261127489 -0.26253096910476686
7.7854144871100202 -0.6985284261127489 -0.26253096910476686
6.4318998173102155 -0.87478714906654531 -0.86019613073348999
6.1403548221930278 -0.89606258008918926 -0.87820239356994645
-2.8021480196038469 0.15900520240821667 -0.7368976174926759
-2.808996283764003 0.18905997884788336 -0.67893737382888797
6.9963656730231065 0.71426218465843017 -0.69864993997573865
6.9963656730231065 0.65802121831931892 -0.75874859720230114
6.7818102421149034 0.67597253053703132 -0.76815976451873791
-0.96230557346737222 -0.12286041183083529 0.46814318862915033
-0.96224511204159091 -0.27140205314598254 0.43291218986511226
-0.96224511204159091 -0.25176006469211748 0.39423488983154281
-0.96230557346737222 -0.12285644543362061 0.42480683189392082
7.7854154948004508 0.31674704689063848 -0.24912928470611584
7.7854154948004508 0.36269225116767706 -0.24460406188964851
7.7847514268072855 0.3615452475360853 -0.1423940216064454
7.7847514268072855 0.29570577793159314 -0.14887857250213635
7.7854154948004508 0.59367407526054206 -0.43416604622840882
7.7854154948004508 0.59819929807700933 -0.4801112347602845
7.7828337919195896 -0.1228603207118551 -0.37601596313476571
7.7828358073004509 0.030548227386854351 -0.4140362490081787
7.2899824796637303 -0.0072503036113756407 -0.37738150962829597
7.7828337919195896 -0.1228603207118551 -0.37601596313476571
0.9820378971442002 -0.51550756504020856 -0.19296433601379404
0.3339226511725204 -0.51882283506355464 -0.28955275480270393
0.33401586253726651 -0.56740922744713007 -0.28838947067260751
0.9820378971442002 -0.5832812019535083 -0.1904905819702149
7.0049008109625595 -1.1303875116535202 -0.35782173454284677
7.0049008109625595 -1.0306672224994677 -0.36433639019012459
6.7631498307379498 -1.0486631250186937 -0.33460842035293592
6.7673317460211528 -1.1418374571414964 -0.34287951190948496
7.2899814719733023 -0.87533558458290261 -0.20140563278198251
7.0049008109625595 -0.90340643899879625 -0.16756694728851329
6.1403558298834584 0.7265782400707228 -0.17658448553085335
7.7854154948004508 0.40863742395438973 -0.24912928470611584
7.7854154948004508 0.45281677671470466 -0.26253096910476686
7.7847514268072855 0.4906939075664502 -0.16808326267242443
7.7847514268072855 0.42738455968894784 -0.14887857250213635
0.78435170787418074 -0.1228658323184515 0.3344353907012938
0.76975833507144586 -0.12288438568658407 0.32420185352325437
0.74193902537906342 -0.20757661818943196 0.30653842586517316
0.75653189433658308 -0.22486142191372088 0.31317312263488756
-0.19503395725643449 -0.41488847900352654 0.23514960506439198
-0.15000833347713791 -0.37940080259285147 0.34953884380340566
-0.20900936390316299 -0.38358827591858086 0.3446720769119262
-3.8531212724724995 -0.1228604576517197 -0.57145819901466377
7.6574851639899029 0.14511195402183358 -0.5702354768943787
7.7854154948004508 0.14511195402183358 -0.5702354768943787
7.7854154948004508 0.16687507572212046 -0.61095163382530226
7.6574851639899029 0.16687507572212046 -0.61095163382530226
7.5697374967535742 -1.2991984576221483 1.7761079837036136
7.78022488139713 -1.2991984576221483 1.7761079837036136
7.7626013834723251 -1.2410295275684373 1.7092159814453125
7.5401325596197859 -1.2410295275684373 1.7092159814453125
2.9451679923590444 -1.4568530109210986 -0.12407716968536384
3.4596418220099232 -2.7579982610126512 -0.16807916893005384
8.6453261075934176 -1.19539324338875 -0.53876664311409006
8.0291737943609967 -1.0604332011600512 -0.57406312601089482
8.0291737943609967 -1.0604332011600512 -0.40371359420776376
8.6453261075934176 -1.19539324338875 -0.43775425865173351
6.4318998173102155 1.2531107232097607 -0.56110381771087658
6.1687112308844343 1.2606983802227003 -0.31582220512390147
7.7828358073004509 -0.26977512120208913 -0.47987565563201912
7.7828358073004509 -0.27625968784294302 -0.54571455841064465
7.8234739469488872 -0.21824015576801475 -0.56359048278808599
7.8234739469488872 -0.20762744357547935 -0.45583694850921641
1.0589423115118759 0.36152802232780279 -0.89902310428619403
1.0589423115118759 0.49772853147544682 -0.89902310428619403
1.6732994242438095 0.44536421319999514 -0.98387548797607427
1.6732994242438095 0.35990598712959115 -0.96538764358520524
6.4318998173102155 -1.1492352274890918 -0.29576828384399423
6.4318998173102155 -1.0605938648029345 -0.28604092216491706
6.1403548221930278 -1.0588330517383593 -0.24311740360260017
-0.29427055500423749 -0.60723929384193598 -0.11604587696075447
7.2567790800055274 0.361544932632826 -0.84987278314590464
7.7828358073004509 0.3615449011425001 -0.8173573211479187
7.7828358073004509 0.29570549451865968 -0.81087267578125
7.2567790800055274 0.28716865610160652 -0.84254728309631355
7.7828358073004509 0.6001806064037305 -0.71851139238357553
7.7854154948004508 0.5292207468227369 -0.64663991935729981
7.7854154948004508 0.49353288641013926 -0.67592822126388563
7.7828358073004509 0.54903987623252692 -0.76048157281875617
-3.6804041405144914 0.013332970047376809 -0.56139445767402651
5.797128408008458 -0.67550232191047843 -0.93053963016510033
7.7828358073004509 -1.1181879074665086 -0.38074634542465219
7.7828358073004509 -0.9961562185474413 -0.39515653900146491
7.2899814719733023 -0.99742118493995835 -0.3836048167800904
7.2899814719733023 -1.1164500193592088 -0.37458154729843146
-0.68015426853573169 -0.41843246326408556 0.073937463684081953
-0.23145717976009675 -0.47483110166511711 0.059876844215392973
-1.0882162407342177 -0.43266010742149524 0.084687631149291911
-1.0211919791070208 -0.42826638820610224 0.024631170959472582
7.0049008109625595 -0.61211065832100087 -0.038762508010864345
7.0049008109625595 -0.69008990049324215 -0.052462185363769599
-0.2314574316827043 0.25771950161018203 -0.49531482709884656
5.7686913840826772 0.44585325796165287 -0.013886473121643192
5.7686913840826772 0.36639926084556401 -0.0038035856628419232
6.1403558298834584 0.36639929233588997 0.0022487919998168222
6.1403558298834584 0.45489576803245368 -0.010852947044372648
-3.1640066298333389 -0.39012492755851919 -0.48730962410926831
7.7828358073004509 0.049752681379697981 -0.6090238590526581
7.7854154948004508 0.14511195402183358 -0.5702354768943787
7.7854154948004508 0.1317103011135084 -0.52605596668243415
7.7828358073004509 0.030548132915876561 -0.54571458990097055
7.9164716813238876 -1.299198205699541 -0.25791036209106455
7.9833480643805288 -1.2595740545459764 1.7092159814453125
8.0445451041754499 -1.2991984576221483 1.7761079837036136
-3.8489106380120495 -0.2112458237310427 -0.60709761156082165
-3.6804036366692765 -0.2590445407196062 -0.56139444192886367
-3.6828195744744519 -0.23932615673504051 -0.54095054445266733
-1.0876451321831924 0.16965097944297619 0.22344962638854965
-1.021192231029628 0.17928119346656626 0.22709217536926257
2.0079564390143174 -1.3968683486743945 -0.14016620700836188
1.9134653074225207 -1.4212058360095996 -0.20186835163116462
3.3811644028815047 -2.7579977571674363 -0.2226907628250123
3.4596418220099232 -2.7579982610126512 -0.16807916893005384
3.4042777982672465 -0.60146991973838981 -0.047854898757934673
3.4010098582037709 -0.749695986041643 -0.049461409225463993
7.6574851639899029 -0.60840371162376583 -0.24460406188964851
7.7854144871100202 -0.60840371162376583 -0.24460406188964851
5.8253004093512315 -1.508625248088457 -0.48830849724769604
5.797128408008458 -1.027137031001665 -0.61714126207351694
-0.96183951664364176 -0.3957206325145739 0.10435598487853995
-0.96180626285946214 -0.39513755763969594 0.092354391860961824
-0.68049058521663985 -0.38688293552360703 0.14096500030517575
5.1034443931158799 0.80383081148185553 -0.15375233024597179
5.1173102134283797 0.71528876928367435 -0.14084135959625252
7.9833480643805288 -1.3388223568531052 1.7092159814453125
7.8621853824957624 -1.338822104930498 -0.22332132511138925
-0.1344523643914447 0.48996093874015634 -0.10927847995758065
-0.2942708069268451 0.4977284055141431 -0.11604587696075447
-0.2942708069268451 0.36152780189552136 -0.11604587696075447
-0.1344523643914447 0.33765652883567637 -0.10927847995758065
7.0049008109625595 -1.0306672224994677 -0.36433639019012459
7.2899814719733023 -0.99742118493995835 -0.3836048167800904
5.8253004093512315 1.262913913593672 -0.48830852873802189
5.7971294156988868 0.78142550756492446 -0.61714132505416885
5.1034443931158799 0.80261761518516372 -0.61979964389801034
5.1034443931158799 1.2615547911266309 -0.39600268405914313
6.4318998173102155 -1.1492352274890918 -0.29576828384399423
6.4702625919684191 -1.218006446437456 -0.25518991283416759
0.9820378971442002 -1.154106906871416 -0.084266910705566453
0.9820378971442002 -1.1606157053180712 -0.13295851226806646
1.3276686606940045 -1.1735230860706347 -0.095800746421814034
1.3276686606940045 -1.1686789922138232 -0.073547225875854591
5.1173092057379499 -0.86621308908424555 -0.089276202812194949
5.0012494681891226 -4.3540567114826212 -0.24939427579879772
5.0301510374029883 -4.3286299107929249 -0.19396550794601444
-0.23145717976009675 -0.5367980169483203 -0.24895007326126109
-2.4738711967889055 0.23729034160651982 -0.5714504366493226
-2.8164274968377332 0.20756750469245738 -0.6160468472862245
6.7631498307379498 -0.85466010724983388 -0.095953285560607962
0.98397215892398515 0.7027257037548047 -0.28022938251495372
0.98397215892398515 0.65403725122489753 -0.28138532939910899
-3.4308853786126354 -0.25339282234630761 -0.78208727437973025
-3.4337850078240613 -0.28707168656311211 -0.75754251771926895
-3.8417983589593154 -0.22675436838588889 -0.66729426668167113
-3.6684383205071667 -0.2827193298908251 -0.66266660583496095
-0.68015426853573169 -0.5084048275562304 -0.49117799021720893
-3.8400202891961315 -0.22084388613186054 -0.6823376362419129
5.1034443931158799 0.80261761518516372 -0.61979964389801034
5.1034443931158799 0.77845112031974617 -0.822397221851349
4.5196278580816998 0.79372342454948253 -0.81944853071212764
4.5196278580816998 0.80285139936485106 -0.61952322181701669
6.0242326078375585 -2.7574326947589891 -0.27267863216400157
6.1687112308844343 -1.5064097147174851 -0.31582220512390147
6.1393955009039658 -1.5064278531452198 -0.2866611241340638
5.9701246702154886 -2.7574326947589891 -0.24005698478698737
4.007016744190099 0.81059751569785898 -0.59435228002548224
4.5196278580816998 0.80285139936485106 -0.61952322181701669
5.3955325333746682 -4.4298168933673878 -0.32453227182388317
5.1862513541754502 -4.435319386958696 -0.30834879501342782
6.4318998173102155 -0.1228604576517197 -0.72473032238006596
6.4318998173102155 -0.018668963460542507 -0.72703793346405032
6.7818102421149034 -0.013689917811967682 -0.67835152780532848
-3.445726139415858 0.10218471960105721 -0.65648861326217667
-3.4502753578606828 0.10645518568076912 -0.61798476194381724
-3.151951629222987 0.1656535344890577 -0.58933810691833499
-3.1458062291375382 0.16029199159660165 -0.64135174892425539
0.3339226511725204 0.26288262395896739 -0.37469239324569709
0.3340153586920514 0.3216977669910413 -0.37441342044830328
-0.9619072838250381 -0.42763862855873286 0.22819641513824462
-0.9619072838250381 -0.38733434934578109 0.21659298580169667
-0.96210428730404229 -0.33866527911148248 0.31745448436737062
-0.96210428730404229 -0.37155218524894884 0.34442991630554193
-3.9396919572869527 -0.17287795944891149 -0.64913326038360608
-0.96180626285946214 -0.43663122646293812 0.092354391860961824
-0.96180626285946214 -0.39513755763969594 0.092354391860961824
-0.96183951664364176 -0.3957206325145739 0.10435598487853995
-0.96183951664364176 -0.43730323001823596 0.10429766479492174
7.6574851639899029 -0.84391088449440177 -0.48011118752479565
7.6574851639899029 -0.83938566167793438 -0.43416599899292002
6.4318998173102155 -0.24363601721248801 -0.17259056749343879
6.4318998173102155 -0.29604191059074575 -0.12775454696655286
6.7631498307379498 -0.30494142309150873 -0.1495086939239503
7.7847504191168566 -0.36862116018257318 -0.24124013931274424
7.7847504191168566 -0.32665099549255538 -0.29238090097427377
0.9820378971442002 -0.50759533723793204 -0.58941341603279118
0.9820378971442002 -0.5832812019535083 -0.58941341603279118
0.33401586253726651 -0.56740922744713007 -0.37441342044830328
0.3339226511725204 -0.50859417888603387 -0.37469236175537118
-0.96230557346737222 -0.12285644543362061 0.42480683189392082
-0.96224511204159091 -0.25176006469211748 0.39423488983154281
-0.68015426853573169 -0.23432179286441979 0.43634526519775391
-0.68015452045833924 -0.12285648510405074 0.45163419631957991
6.7631498307379498 0.36639919786491221 -0.019105931663513272
7.0049008109625595 0.36639919786491221 -0.038762445030212457
7.0049008109625595 0.44437844003715338 -0.052462185363769599
6.7631498307379498 0.45246043218650639 -0.030226299400329698
-0.68015452045833924 0.081674141359708963 -0.80563189828872683
-0.68015452045833924 -0.0062496827598589079 -0.85868774412155158
0.9820378971442002 0.50052430559196293 -0.065793803787231528
1.6732994242438095 0.50336284357108896 -0.038963668212890677
0.80393113292300888 -1.1366316024204273 -0.28889564617156993
0.81775211101138734 -1.1952961272235887 -0.2655011996269227
0.68135365367496148 -1.1328882843967456 -0.26290044509887706
7.2567790800055274 0.14973933145561047 -0.78562200048446662
7.7828358073004509 0.1740501149944288 -0.76048119493484512
7.7828358073004509 0.12290936907806221 -0.71851095151901256
7.2567790800055274 0.09196758888282601 -0.73820981937408459
0.9208630265387312 -0.99884996400795156 -0.73119827787399305
1.0075516111334581 -1.0936030321308152 -0.77226169437408454
2.7050912897833608 0.50490813684501479 -0.034326654739379993
2.7050912897833608 0.71807371072807125 -0.032131401138305732
2.7019815571173447 1.2090165832714064 -0.12582677219390875
4.0095737586554305 0.36565278266944706 -0.079078438644409249
4.5196278580816998 0.25726308082618538 -0.070410915374755953
4.5196278580816998 0.36654014856376471 -0.055282207031250107
-0.1343470607415419 -1.0930578716083545 -0.12775146091461187
0.37434917583072386 -1.1204320340534228 -0.10788100227355969
5.7971274003180282 -0.12286045755946289 -0.79227653615951543
6.1403548221930278 -0.1228604576517197 -0.76615795598983771
6.1403548221930278 -0.225079697107889 -0.76802331693649295
5.797128408008458 -0.23371798948249992 -0.80707065979003922
-3.1781440227166393 -0.28735451692543201 -0.36765701356887825
-3.4696643294183001 -0.25339283021888909 -0.45388191885948187
2.7019815571173447 -1.4547279177661914 -0.12582677219390875
2.7019815571173447 -1.4547279177661914 -0.12582677219390875
5.3236015751227157 -4.4573757150836961 -0.31673951831817637
5.2464679111822861 -4.4628782086750052 -0.30934133859634411
-2.4738711967889055 0.086645660820387049 -0.82056413848876952
-2.4738711967889055 0.14033186425247018 -0.77188173210144051
-2.1520587080804092 0.1604489708713514 -0.75875987073898321
-0.96183976856624931 0.19159167509116953 0.10429766479492174
-0.96183976856624931 0.15000914056815925 0.10435598487853995
6.4702625919684191 -1.218006446437456 -0.25518991283416759
5.1034443931158799 0.6659547650722486 -0.93912137378692639
5.1034443931158799 0.42979092443504158 -0.94967743488311773
4.5196278580816998 0.42979086145438972 -0.97059872570037853
4.5196278580816998 0.6926596951107008 -0.96311316032409677
-1.0882162407342177 -0.43266010742149524 0.084687631149291911
-1.088148725475429 -0.43344119346580684 0.10393514816284172
-1.0882550368157609 -0.3854206035133379 0.09740695167541491
-1.0883202847710831 -0.38476095991096665 0.079633055953979376
2.0079564390143174 0.33593016618766608 -0.9832248978424073
2.0079564390143174 0.24175324506797619 -0.93477608669281009
7.2567790800055274 0.044555565224073571 -0.68043795083999647
7.2567790800055274 0.0093252907375318255 -0.61452649435043349
6.9963656730231065 -0.0073752887149828228 -0.64943074949264534
6.9963656730231065 0.013418293085477996 -0.69864924718856825
-3.6582939009515032 -0.21529921912155325 -0.74852107467651374
7.0049008109625595 0.070173165798566986 -0.17116692134857187
7.2899824796637303 0.095168202629469081 -0.2037511267280579
7.2899824796637303 0.15221204631843391 -0.15675757801055917
7.0049008109625595 0.13264679191627327 -0.11964912601470952
7.2567780723150985 -0.98362880006752185 -0.58375723390579226
-0.1342236186639052 0.67398939577140626 -0.11706125102996831
-0.2942708069268451 0.6733172032741529 -0.12292178962707526
5.1034443931158799 -0.67550225892982652 -0.94967737190246593
5.1034443931158799 -0.41449343286476309 -0.94835427436828623
5.797128408008458 -0.52259581697426016 -0.92930665794372569
7.5401325596197859 -1.3573668838306445 1.7092159814453125
7.5697374967535742 -1.2991984576221483 1.7761079837036136
7.3509114738043566 -1.2991984576221483 1.7761079837036136
7.3690035477789655 -1.3388223568531052 1.7092159814453125
-3.1210548329583387 -0.058942925362207237 -0.85082848304748537
-2.7853044740716202 -0.04796604329548055 -0.8794507960510255
1.3132758182867783 0.87521856161155531 -0.35444376728057869
-2.1520582042351943 -0.28251788627586538 -0.85247142782211316
-2.1520582042351943 -0.34840764593086415 -0.81252232799530033
7.2899814719733023 -0.23846125131569085 -0.37738150962829597
7.2899814719733023 -0.25503705035171687 -0.32273855136871343
7.7847504191168566 -0.2954643622680681 -0.3507269956016541
7.7828358073004509 -0.27625978231392079 -0.41403621751785286
7.7828358073004509 0.080939220133207479 -0.66737009538650527
7.7828358073004509 0.049752681379697981 -0.6090238590526581
4.5196278580816998 0.53800705160178963 -0.078656090393066536
0.37424387218082106 0.50052424261131112 -0.089407958335876572
5.7686903763922466 -0.86282567472419913 -0.087169374046325729
5.7686903763922466 -0.93196810163459953 -0.13962646282196051
-0.23145717976009675 -0.4391071848293322 -0.65236917478561407
-3.4718197792474017 -0.030742504000284027 -0.43564380849838258
-3.4731474113885148 -0.072434798054315394 -0.42441262630462651
-3.1828484254876357 -0.058942846636392418 -0.32784782526016243
-3.1810557442132219 -0.0065981547065752126 -0.34301964385986339
0.9820378971442002 -0.5832812019535083 -0.1904905819702149
0.37424387218082106 -0.58329965528450189 -0.089407958335876572
0.9820378971442002 -0.58329965528450189 -0.065793803787231528
-0.10915605961239153 -0.12299624836544717 0.47206234863281238
-0.10741653400814348 -0.22817399951420003 0.46015623428344715
-0.10982441028988219 -0.21032854202709372 0.4287188121032714
-0.11164455112850524 -0.12295222384422297 0.43906804473876943
1.3084782041510363 1.0981795792583446 -0.2086340166664124
5.7686913840826772 0.78590884824790785 -0.22082880283355719
5.7971294156988868 -0.011993573317148041 -0.80707072277069103
2.7050912897833608 0.34750619894065682 -0.036456030578613387
3.4042777982672465 0.35575845928230115 -0.047854835777282785
5.1173092057379499 -0.78332822095832999 -0.053365327911377027
-2.824154970897792 -0.45952831479988271 -0.55064287314414984
-2.8164269929925188 -0.45327905961952381 -0.61604678430557258
6.1403558298834584 0.61767228582420175 -0.079410472640991256
6.1403558298834584 0.53983109724082767 -0.03878329162597665
6.4318998173102155 0.54452397455253421 -0.045367225990295461
6.4318998173102155 0.62181634973563971 -0.087033146896362434
7.2899824796637303 0.044555817146681005 -0.25682722084045417
7.7847514268072855 0.080939472055814921 -0.29238093246459967
7.7847514268072855 0.12290958951034371 -0.24124013931274424
-2.4738706929436902 -0.38604343492469961 -0.2182812039756776
-2.8521642302361712 -0.3642699529071825 -0.31358566770553598
0.71878280315005971 0.073257611732862646 0.2568761035156249
-1.0856982742730361 0.10682231564559763 0.32807226650238031
-1.021192231029628 0.12160033197440928 0.34086754169464112
-1.021192231029628 0.17928119346656626 0.22709217536926257
-1.0876451321831924 0.16965097944297619 0.22344962638854965
2.7019815571173447 0.83455365518607916 -0.52692824871063237
7.7828358073004509 0.6001806064037305 -0.71851139238357553
7.7828358073004509 0.54903987623252692 -0.76048157281875617
7.2567790800055274 0.57335072275199717 -0.78562237836837778
7.2567790800055274 0.62975789503135504 -0.73754335811614991
6.9963656730231065 0.42979086145438972 -0.87902989635467543
7.2567790800055274 0.42979086145438972 -0.84254740905761738
-3.4667652040520891 0.041360115890882669 -0.47842691169738782
-3.4632312337151747 0.068999600077055148 -0.50833486449241649
0.98397215892398515 -0.94843710123024161 -0.28022938251495372
-0.20538747257625914 -0.97792155637703115 -0.22928017650604252
-3.4413507475701555 -0.33524905110321218 -0.69351279714584357
-3.1398961247674206 -0.39012492755851919 -0.69136654249191298
-3.1458057252923233 -0.40600354652366805 -0.64135168594360359
-3.4457256355706436 -0.34789625878296065 -0.65648855028152475
4.007016744190099 -0.0072457060237901957 -0.84966683641433727
6.7631498307379498 0.53365855249442873 -0.056222886047363335
6.7631498307379498 0.60894864679374516 -0.095953222579956157
6.4318998173102155 0.19510867214240854 -0.038526204605102643
6.4318998173102155 0.28079879297294441 -0.016038081130981499
6.1403558298834584 0.27564417301215949 -0.012560919342041069
6.4318998173102155 -0.2270426150842684 -0.72703787048339852
6.242801669727208 -4.0190895799823778 -0.30948805202484136
6.2861938273199822 -4.0344525763507857 -0.27057394474029545
5.7686913840826772 0.26807588254966563 -0.022416257705688603
7.3509114738043566 -1.2991984576221483 1.7761079837036136
7.3690035477789655 -1.2595744324298876 1.7092159814453125
-2.4738711967889055 -0.041064702190973107 -0.879014403114319
-2.4738711967889055 0.025395607061765843 -0.85673839847564703
-1.0211919791070208 -0.50489154636345079 -0.069601551017761276
5.1034443931158799 -1.0483290126606006 -0.61979958091735854
4.5196278580816998 -1.0485628598209398 -0.61952315883636477
6.1403548221930278 -1.364185421123125 -0.28365304224014293
5.7900191520270132 -1.3425440095325487 -0.24544513700485235
-3.1344495579949601 -0.36433954652748279 -0.73746044408798228
-2.802147515758632 -0.40471672584495716 -0.73689755451202399
-2.8089957799187881 -0.43477150228462397 -0.67893731084823616
5.7686903763922466 -0.4250254668422716 -0.050423123779297002
6.4318998173102155 0.11639389468231029 -0.078816187210083113
7.7847504191168566 -0.79475158861122308 -0.19926989589691166
7.7847504191168566 -0.84589244474373027 -0.24124013931274424
7.7854144871100202 -0.77493245920143294 -0.31358248718261728
7.7828358073004509 -0.93825375963173085 -0.41403634347915658
7.7847504191168566 -0.91904913244209463 -0.35072705858230602
7.7847504191168566 -0.88786262517891101 -0.29238090097427377
7.7854144871100202 -0.80422085557899647 -0.34927037908554087
3.4010098582037709 1.0378060744670849 -0.075345575408935619
3.4010098582037709 1.1476012525371533 -0.12085974010467541
6.7631498307379498 0.12452590921439949 -0.096777513351440553
7.0049008109625595 0.20398944789924453 -0.080473963928222744
6.7631498307379498 0.19985234334983651 -0.056250408592224244
-3.1228470103875381 -0.23911335298500233 -0.83565663295745862
5.7686903763922466 -0.6915647813983935 -0.013886536102294993
6.1403548221930278 -0.7006072284885424 -0.010853010025024539
6.1403548221930278 -0.61211075279197869 0.0022487290191649306
7.6574851639899029 -0.80422085557899647 -0.34927037908554087
7.7854144871100202 -0.80422085557899647 -0.34927037908554087
0.69226946025455138 -0.28983381326637442 0.30514743518829346
0.67767608745181729 -0.26155238304100209 0.29987110511779774
-2.4738711967889055 0.02539567004241769 -0.13342463207244881
-2.8607517680779675 0.013045431881330671 -0.24091279737472543
-2.8630059715691791 -0.047965964569665731 -0.22183523365020758
-2.4738711967889055 -0.041064615592576813 -0.11114869041442879
-3.852400773815273 -0.08107855400047477 -0.57756245698928843
-3.6862749449578507 -0.057824381112672636 -0.51170569919586195
3.4010098582037709 -1.1319266328235644 -0.065125956954956182
6.7631498307379498 0.80295179052390864 -0.33460845184326182
6.7631498307379498 0.76192575304069343 -0.28173569076538096
7.0049008109625595 0.74481151666679202 -0.30289117513656627
7.0049008109625595 0.784955699062727 -0.36433639019012459
6.4318998173102155 0.46233668012656992 -0.016672926101684624
-1.0211919791070208 -0.23939553779564077 -0.84751245725631719
-1.0211919791070208 -0.32627171026191887 -0.79537414505004889
-1.6814199159661514 -0.31594097819290334 -0.83175979959487922
-1.6814199159661514 -0.23086855585060292 -0.86902274312973038
-1.0859010719720108 -0.31709232748947319 0.30438524333953848
-1.7035236055413467 -0.29401335102996995 0.041091542205810419
-1.6735579152337294 -0.34540664936027704 0.022757118682861219
-1.0859010719720108 -0.31709232748947319 0.30438524333953848
6.1403548221930278 -0.28810279005012684 -0.12134998149871835
-1.0856982742730361 0.10682231564559763 0.32807226650238031
-1.0859013238946182 0.071380756817243735 0.3043853063201904
1.3084782041510363 -1.2664014091297169 -0.30242247312545789
1.3084782041510363 -1.3438910397144335 -0.2086340166664124
0.9820378971442002 -1.2894761343952197 -0.21057523780822759
-2.839313658031581 0.18905997884788336 -0.42234843544006351
-2.8461619221917371 0.15900520240821667 -0.36438812879562382
6.9963656730231065 0.59722316095390138 -0.81568896368026733
6.7818102421149034 0.59859078580894287 -0.82524275068283082
6.1403548221930278 -0.97358388994178957 -0.80840216524124153
4.5196278580816998 0.10883716116943187 -0.93275478565216075
4.5196278580816998 0.17138512020149058 -0.95911250335693365
-2.7875581737176161 0.013045400391004726 -0.86037320083618163
-2.7912196168938856 0.069273786344907926 -0.82939273477554332
5.797128408008458 -0.29948211848220996 -0.85160645154953007
6.1403548221930278 -0.29428955267868218 -0.83507919485092175
1.0272519590338489 -0.74343999193153554 -0.88317786506652851
1.0589423115118759 -0.74343999193153554 -0.89902304130554211
5.188093412280919 -4.435319386958696 -0.19656890766143809
2.7050912897833608 -1.145040905017473 -0.043100426368713446
6.4318998173102155 -0.94566947946510493 -0.79356427005767827
7.8601962015875602 1.0138627200511914 -0.25392548177719121
7.7626013834723251 0.99531831903495604 1.7092159814453125
1.6732994242438095 -1.0338679622074145 -0.95940706386566177
1.6732994242438095 -0.89367057493171853 -0.9735260034179688
4.007016744190099 -1.0563089761539477 -0.59435224853515634
3.9515564860113881 -1.4804624419208543 -0.39081975429534921
0.33469051127994204 -0.46615173803291493 -0.60248309792518628
-0.23145717976009675 -0.47555616641960319 -0.57376203125953684
2.0079564390143174 -0.42707668369255242 0.0014168805694578814
1.6732994242438095 -0.4354616442676561 0.010335192794799731
5.7971294156988868 0.42979086145438972 -0.93053969314575202
6.1403558298834584 0.42979086145438972 -0.91218278553009036
6.1403558298834584 0.32097890583076299 -0.91525964229583745
7.2567780723150985 -1.3683653210254687 -0.34757213729858405
-0.10741678593075105 -0.017537555412866418 0.46015623428344715
-0.16518163212215745 -0.013045814685441798 0.46738414581298815
-1.6814204198113663 0.19816480827369515 -0.71098898332595828
4.0095732548102161 -0.4979153055187242 -0.075429276695251582
3.4045287131842397 -0.46909926403007685 -0.049497434158325304
-0.2314574316827043 0.29689803316154301 -0.15433716857910162
-0.68015452045833924 0.29650556922950572 -0.15020034744262706
-0.68015452045833924 0.27142799625434705 -0.058553044204711982
6.4318998173102155 0.42979092443504158 -0.90269752147674565
6.4318998173102155 0.52603707487144291 -0.89039393623352059
6.7818102421149034 0.51735827806510748 -0.8644161493110657
6.7818102421149034 0.42979092443504158 -0.8853998854446411
-0.96210428730404229 -0.33866527911148248 0.31745448436737062
-0.68015426853573169 -0.32607886350593746 0.37069958705902101
7.2899824796637303 0.36639922935523805 -0.087392766418457155
7.7847514268072855 0.3615452475360853 -0.1423940216064454
7.7847514268072855 0.42738455968894784 -0.14887857250213635
7.2899824796637303 0.43615171834983646 -0.097308818130493233
3.4010098582037709 -0.94813063737831282 -0.049278261489868268
6.1403558298834584 0.048577997751615691 -0.83507925783157355
7.2899824796637303 0.50659564043083016 -0.11950534118652356
7.2899824796637303 0.57227866609611333 -0.15394574382781989
7.0049008109625595 0.5946119831279737 -0.11494226699829106
7.0049008109625595 0.52195151998557865 -0.077553551101684659
-0.68015452045833924 0.29679767349281139 -0.24481328361511237
-0.074266038097498946 0.16117639740028206 0.21722455577850341
-0.075138446087001334 0.11308337969817941 0.21755432247161849
7.2567780723150985 -0.39545088638267689 -0.78562193750381482
7.7828358073004509 -0.41976157545051745 -0.7604811319541932
2.0079564390143174 -0.69107567365608391 -1.0007653872680664
1.6732994242438095 -0.69107579961738763 -0.98387542499542258
1.6732994242438095 -0.60561751056633173 -0.96538758060455332
2.0079564390143174 -0.58164165813408075 -0.98322483486175549
2.0079564390143174 -1.31272456029854 -0.079617049179077193
2.0079564390143174 -1.3968683486743945 -0.14016620700836188
5.1173102134283797 0.26550331186332526 -0.041782304306030381
6.7631498307379498 0.28190933080711189 -0.032337914695739871
6.4318998173102155 0.36639919786491221 -0.0018081696701050887
-3.4373184743157608 -0.31471117074928456 -0.72763451768875131
-2.4738706929436902 -0.38604343492469961 -0.77188166912078859
5.7686913840826772 0.61711421426811042 -0.087169311065673938
5.7686913840826772 0.5339605447200757 -0.041464944801330617
5.1602972794684181 -4.4552192575641651 -0.25201584543228162
5.1862513541754502 -4.435319386958696 -0.30834879501342782
-1.0876451321831924 0.16965097944297619 0.22344962638854965
-1.087771597332118 0.12444116874732798 0.20777191570281972
6.1403558298834584 0.76479074289359872 -0.72123158971786505
6.4318998173102155 0.69995814497031994 -0.79356433303833007
6.4318998173102155 0.69995814497031994 -0.79356433303833007
6.1403558298834584 0.72787236650504894 -0.80840219673156744
1.6732994242438095 0.78815650175132579 -0.95940712684631368
1.6732994242438095 0.6479589255336744 -0.97352606639862072
1.0591710572394148 0.66229892717399419 -0.89902310428619403
1.0590481190069931 0.84789169763603034 -0.89902310428619403
0.98397215892398515 0.51710559968986336 -0.27662654283523563
0.98397215892398515 0.48589314439811532 -0.27678257740020756
4.007016744190099 0.76894526159324472 -0.92040333511352546
4.007016744190099 0.71622340215720948 -0.9642564480972291
0.81775211101138734 -1.2532787605091114 -0.21334944105148324
5.2365995988043563 -4.4894112015338914 -0.25327353755950938
5.2483109769781837 -4.4628782086750052 -0.19756141975402838
5.188093412280919 -4.435319386958696 -0.19656890766143809
5.1602972794684181 -4.4552192575641651 -0.25201584543228162
6.1403548221930278 -0.225079697107889 -0.76802331693649295
6.1403548221930278 -0.24516125902137931 -0.79497065950393686
6.1315103232916615 -1.2370944964405077 -0.23805549116134653
5.7829098960455676 -1.2565944399066942 -0.24123547874450688
0.33469051127994204 0.13537457841911141 0.21385301254272449
1.0074452997931258 0.4977287204174024 -0.77226175735473634
1.0272519590338489 0.49772853147544682 -0.88317792804718021
1.0272519590338489 0.36928292446174449 -0.88317792804718021
1.0074452997931258 0.36152799083747683 -0.77226175735473634
-3.4548250801507221 0.10218471960105721 -0.57948086338996896
-3.45919896046078 0.089537511921308696 -0.54245661652565003
-3.1640071336785538 0.1444134356121046 -0.48730965559959416
-3.1580975331536512 0.16029199159660165 -0.53732446491241459
-3.938675701488612 -0.17597817416391545 -0.65773348882675176
-3.8472731410638072 -0.22084388613186054 -0.62096169990539563
4.5196278580816998 0.74831355581321535 -0.91656189323425308
4.007016744190099 0.76894526159324472 -0.92040333511352546
4.007016744190099 0.8065716664699536 -0.812582600479126
-0.68015452045833924 -0.011389762062646684 0.43634526519775391
-0.96224536396419846 0.0060484940198880918 0.39423501579284659
0.3339226511725204 0.27311137460746587 -0.28955278629302983
0.3340153586920514 0.3216977669910413 -0.28838950216293346
0.3340153586920514 0.3216977669910413 -0.37441342044830328
0.3339226511725204 0.26288262395896739 -0.37469239324569709
4.007016744190099 -0.0072457060237901957 -0.84966683641433727
4.007016744190099 0.11767477943458385 -0.93524989013671889
4.5196278580816998 -0.0074332072969453952 -0.8540308917427063
2.0079564390143174 -1.4322122087665574 -0.25337717222213757
1.6732994242438095 -1.3932304602619188 -0.20102576498031627
1.6732994242438095 -1.3046551012989063 -0.32077994756698613
7.2834385380133408 -1.2302770927997606 -0.28156151777267463
6.4318998173102155 -1.4961088512226124 -0.28979611204147349
6.4325024161871687 -1.3808126910968799 -0.28251548570632939
5.1034443931158799 0.73729786191978286 -0.90896397037506116
0.3346900074347276 -0.12340856442629571 0.38803179946899408
0.76975833507144586 -0.12288438568658407 0.32420185352325437
-3.8529403920403702 -0.10056278576216872 -0.57299909938812266
-3.687182874034999 -0.087568265373327084 -0.50402849944114692
2.0079564390143174 0.50336271760978524 -0.025304298477172922
2.0079564390143174 0.71388480459251236 -0.035276654891967844
0.9820378971442002 -0.5832812019535083 -0.58941341603279118
1.0074452997931258 -0.6072394198032397 -0.77226169437408454
0.33627510448062559 -0.6072394512935656 -0.45456061410903936
0.33401586253726651 -0.56740922744713007 -0.37441342044830328
-3.122847514232753 -0.0065982176872270808 -0.83565669593811054
-3.1257587318841202 0.04164296199836557 -0.8110189798355103
-1.082313442119716 -0.12286023786523589 0.43227117279052724
2.0079564390143174 -0.42707668369255242 0.0014168805694578814
2.0079564390143174 -0.48193346126518427 -0.022294579086303765
2.7050912897833608 -0.35501264732322868 -0.019435257492065483
1.6732994242438095 -0.58755160505256832 -0.062932277870178313
1.6732994242438095 -0.46551412191353014 -0.062116615447998097
7.2567790800055274 0.21565072496452159 -0.82085240093231215
-1.021192231029628 0.2965728640560133 -0.32478746942520148
-0.68015452045833924 0.29372711479224978 -0.32920899459838876
-1.0832616788140519 -0.25680523215255913 0.40297332931518548
-1.0856980223504289 -0.35253385482750116 0.32807220352172839
-1.0211919791070208 -0.36731190264663871 0.3408674787139892
-1.0211919791070208 -0.26834635787925898 0.42667395629882809
-0.20900936390316299 -0.38358827591858086 0.3446720769119262
-0.15000833347713791 -0.37940080259285147 0.34953884380340566
-0.21951630009090745 -0.30784020206413443 0.42798811058044417
7.7847514268072855 0.54904000219383065 -0.19926989589691166
7.7847514268072855 0.60018092130698975 -0.24124013931274424
7.2899824796637303 0.6296239981655104 -0.20140563278198251
-3.6582944047967181 -0.030412351550676169 -0.74852110616683964
-3.6602760280266979 -0.006385429682351903 -0.73174321796417241
5.1173102134283797 0.537616886463545 -0.053365327911377027
5.1173102134283797 0.45331507963218509 -0.02881005348205579
-3.4337855116692766 0.041360115890882669 -0.75754254920959474
-3.4373189781609756 0.068999600077055148 -0.72763458066940323
-3.1344500618401749 0.11862800734557929 -0.7374605070686342
-3.1296766322747449 0.083926660118482765 -0.77786218585968026
-1.6814204198113663 0.2830737800792677 -0.33459358840942394
1.3084782041510363 1.0206900746349317 -0.30242247312545789
0.9820378971442002 0.97633821786918462 -0.28294217962265023
0.9820378971442002 1.0437646739391309 -0.21057523780822759
1.3084782041510363 1.0981795792583446 -0.2086340166664124
-1.7619968581048233 -0.24001961307487663 0.069360155868530185
-1.728542543529628 -0.32520618784866512 0.042950982971191334
-1.7035236055413467 -0.29401335102996995 0.041091542205810419
-1.735664899486659 -0.22207108775100884 0.065478910217285025
2.7019815571173447 0.44596322217979256 -0.98570784706115744
3.4010098582037709 0.44131487218894777 -0.98946357227325454
2.0079564390143174 0.33906628774680914 -0.023979059600830167
2.0079564390143174 0.23622200080909558 -0.022294579086303765
2.7050912897833608 0.22610954393424812 -0.039333679542541557
-1.021192231029628 0.25918008590736213 -0.069601488037109485
7.7847504191168566 -0.41976195333442862 -0.19926989589691166
-0.2942708069268451 0.4977284055141431 -0.18747906763076791
-0.2942708069268451 0.4977284055141431 -0.11604587696075447
7.8601962015875602 -1.2595738026233689 -0.25392548177719121
7.7626013834723251 -1.2410295275684373 1.7092159814453125
7.6574851639899029 -0.65434888441047845 -0.24912928470611584
7.7854144871100202 -0.65434888441047845 -0.24912928470611584
7.7828358073004509 0.23239630409278694 -0.79166792263031016
6.4318998173102155 0.73030411245384041 -0.19544212081909187
6.7631498307379498 0.72704020315208262 -0.21441863208770756
6.1403548221930278 -0.78554255769691639 -0.038783354606628545
5.7686903763922466 -0.77967200517616453 -0.041465007781982512
-1.8379051704827529 -0.1228604576517197 0.060776900711059512
-2.1520587080804092 -0.1228604576517197 -0.020771580963134837
-2.1520582042351943 -0.21102330521545584 -0.029078099136352609
7.0049008109625595 0.0088282159427625385 -0.22729367227554328
6.1403548221930278 -0.5213556334682482 -0.012560919342041069
-0.68015426853573169 -0.47991389219246083 -0.56962522586822517
0.98397215892398515 0.5176415020565015 -0.45805100183486946
0.98397215892398515 0.4858930814174634 -0.45805100183486946
0.98397215892398515 0.48589314439811532 -0.27678257740020756
0.98397215892398515 0.51710559968986336 -0.27662654283523563
-0.96224511204159091 -0.27140205314598254 0.43291218986511226
-0.96230557346737222 -0.12286041183083529 0.46814318862915033
-1.0211917271844131 -0.12286032074260735 0.46070958229064934
-1.0211919791070208 -0.26834635787925898 0.42667395629882809
7.7828358073004509 -0.91904900648079091 -0.60902441013336184
7.7828358073004509 -0.88786249921760729 -0.66737053625106824
7.7854144871100202 -0.80422072961769275 -0.61095194872856151
7.7854144871100202 -0.82598394578895729 -0.57023585477828986
-0.68015426853573169 -0.47601224081001453 0.013883963584899812
7.7828358073004509 0.42979086145438972 -0.81087280174255383
1.6732994242438095 1.0589440187267285 -0.32077997905731209
1.6732994242438095 1.1475193776897412 -0.20102576498031627
7.7828358073004509 0.29570549451865968 -0.81087267578125
7.7854154948004508 0.3167468579486829 -0.71109299587249764
7.7854154948004508 0.27256731624641245 -0.69769121700286874
7.7828358073004509 0.23239630409278694 -0.79166792263031016
0.92069474223697367 -0.70321840631447019 -0.73119780551910407
1.0074452997931258 -0.6072394198032397 -0.77226169437408454
2.7019815571173447 -1.0702313530918139 -0.92457007205963138
0.98397215892398515 0.71924527681388684 -0.67641062156677256
0.98397215892398515 0.64756743780174075 -0.67641014921188358
0.98397215892398515 0.64754243448295423 -0.45805100183486946
0.98397215892398515 0.72579280836143323 -0.45872851619720467
7.8601962015875602 -1.2595738026233689 -0.25392548177719121
8.6453271152838482 0.94968190889396487 -0.43775429014205935
8.6453271152838482 0.94968190889396487 -0.53876667460441596
8.6453271152838482 1.0542364669231397 -0.53871747097015388
8.6453271152838482 1.0542364669231397 -0.43719813949584968
7.7854144871100202 -0.60840371162376583 -0.24460406188964851
7.7847504191168566 -0.60725670799217391 -0.1423940216064454
7.7847504191168566 -0.67309614610634028 -0.14887857250213635
7.7854144871100202 -0.65434888441047845 -0.24912928470611584
3.4010098582037709 0.021382149277113124 -0.83872996280670165
-2.4738711967889055 0.086645692310712993 -0.16959873460769664
1.3132758182867783 -1.1209300220676439 -0.35444376728057869
1.3084782041510363 -1.0991587443729418 -0.54336742696762097
7.7847504191168566 -0.84589244474373027 -0.24124013931274424
5.3256461790045506 -4.4573757150836961 -0.19270957927703866
-0.2314574316827043 0.273954087219618 -0.41582880432128916
-1.0876448802605851 -0.41536247138939075 0.22344956340789793
-1.0877713454095108 -0.3701527394195574 0.2077718527221678
0.67767608745181729 -0.26155238304100209 0.29987110511779774
-1.6814204198113663 0.23801147007026496 -0.63806151371002207
-1.6814204198113663 0.26479710981406995 -0.56330782562255877
-1.021192231029628 0.2394063655475599 -0.56614182899475107
-1.021192231029628 0.19863902109184089 -0.64332235054016118
-2.8570908287469132 -0.31498538850746327 -0.27189294853210455
3.4010098582037709 0.021382149277113124 -0.83872996280670165
-0.9619072838250381 -0.38733434934578109 0.21659298580169667
-0.96183951664364176 -0.3957206325145739 0.10435598487853995
6.9963666807135354 1.1595336927989943 -0.61498326152801519
7.2567790800055274 1.1300945207408888 -0.60514607733726511
7.2567790800055274 0.80412921381034663 -0.60858549797058115
6.7673317460211528 -1.1418374571414964 -0.34287951190948496
6.7530910648688094 -1.2223440498920457 -0.27203301750183112
-0.22447791584408125 -0.23515393259964162 0.4681258059692382
5.2365995988043563 -4.4894112015338914 -0.25327353755950938
5.2464679111822861 -4.4628782086750052 -0.30934133859634411
0.33469051127994204 0.12979642931976146 -0.79593665674209602
0.9820378971442002 0.13519676829376048 -0.79156866512298585
0.9820378971442002 0.023892636785886927 -0.85929575933456426
0.33469051127994204 0.02339486920394724 -0.86452312194824221
7.7828358073004509 -1.3557899742694872 -0.60428903662681588
8.0291737943609967 -1.0604332011600512 -0.57406312601089482
8.6453261075934176 -1.2999478014179247 -0.53871743947982798
3.4010098582037709 -1.0418112709613818 -0.92236883529663105
3.4010098582037709 -0.98618424001655747 -0.96495641506195073
-2.4738706929436902 -0.43010252613029654 -0.71256195659637456
5.7686903763922466 -0.24143827587566549 -0.1635095447540284
5.7971294156988868 0.77478482763328382 -0.72785986246109013
5.7971294156988868 0.78142550756492446 -0.61714132505416885
6.1403558298834584 0.77897612703361341 -0.60189205599784867
0.98397215892398515 0.48589327035941904 -0.6764102436828614
0.98397215892398515 0.51768911542930429 -0.6764102436828614
0.92069474223697367 0.49778905588187994 -0.73119783700942997
0.92069474223697367 0.49778905588187994 -0.73119783700942997
0.92069474223697367 0.45750694585838142 -0.73119786849975599
-2.1520587080804092 0.26475207864799327 -0.537413220396042
-3.6746577858391984 0.037007759218595684 -0.61002712509155277
-3.6776481071892961 0.027985025072477517 -0.58471877526283278
7.2567790800055274 0.50743926626243419 -0.82085268434524539
6.9963656730231065 0.51492879941978276 -0.85718723009109499
6.4318998173102155 0.31811854505576914 -0.90060914604187015
-1.021192231029628 -0.12286045768247197 -0.86911016027450572
-0.68015452045833924 -0.12286045759021515 -0.8735317169380189
6.4318998173102155 -0.43031621948204213 -0.88269480346679707
7.7847514268072855 0.4906939075664502 -0.16808326267242443
6.9963656730231065 -0.0073752887149828228 -0.64943074949264534
7.0049008109625595 0.28306112096824471 -0.057003720169067455
4.007016744190099 0.42979086145438972 -0.97823084705352792
4.007016744190099 0.18786825895347423 -0.95728511974334729
0.33638141582095793 -1.1031546777912156 -0.45456061410903936
-3.8436474708977921 -0.016961487135507415 -0.65164974679946908
-3.8454955751458391 -0.018957210158922017 -0.63600516393661499
-3.6715480531731828 0.04005433803596322 -0.63634689695358282
7.7828358073004509 0.024063550529859704 -0.47987568712234502
7.7854154948004508 0.12718512553253 -0.48011115603446969
7.7854154948004508 0.13171039558448619 -0.43416598324775701
7.7828358073004509 0.030548227386854351 -0.4140362490081787
6.4318998173102155 0.67945945432700938 -0.13757593875885016
6.1403558298834584 0.67493838823356456 -0.12529364097595222
-0.20900961582577057 0.13787673673667733 0.34467213989257806
-0.15000858539974546 0.133689263410948 0.34953890678405752
7.6574851639899029 0.49353288641013926 -0.67592822126388563
7.7854154948004508 0.49353288641013926 -0.67592822126388563
7.7854154948004508 0.5292207468227369 -0.64663991935729981
7.6574851639899029 0.5292207468227369 -0.64663991935729981
1.0274807047613876 0.66229892717399419 -0.88317792804718021
1.0272519590338489 0.49772853147544682 -0.88317792804718021
4.5196278580816998 -0.67550232191047843 -0.97059866271972661
7.7854154948004508 0.49353307535209473 -0.28429418527603156
7.7847514268072855 0.54904000219383065 -0.19926989589691166
7.6574851639899029 0.49353307535209473 -0.28429415378570566
7.7854154948004508 0.49353307535209473 -0.28429418527603156
7.7854154948004508 0.45281677671470466 -0.26253096910476686
7.6574851639899029 0.45281677671470466 -0.26253096910476686
0.9820378971442002 0.26979613607444591 -0.19296433601379404
0.9820378971442002 0.33756977298774543 -0.1904905819702149
0.3340153586920514 0.3216977669910413 -0.28838950216293346
0.3339226511725204 0.27311137460746587 -0.28955278629302983
1.0273577665289659 0.84789169763603034 -0.88317792804718021
-1.7779319707146866 -0.12286067276385823 0.090953954086303579
-1.7509742363396865 -0.12311901555373544 0.085419592285156151
7.0049008109625595 0.88467617715873537 -0.35782173454284677
6.7673317460211528 0.89612599668540771 -0.34287951190948496
6.7631498307379498 0.80295179052390864 -0.33460845184326182
7.0049008109625595 0.784955699062727 -0.36433639019012459
7.6574851639899029 -0.83938566167793438 -0.52605636031150826
7.7854144871100202 -0.83938566167793438 -0.52605636031150826
7.7854144871100202 -0.83938566167793438 -0.52605636031150826
2.0079564390143174 1.1511572661022169 -0.14016620700836188
3.4596418220099232 2.5122866745952592 -0.16807916893005384
3.3811644028815047 2.5122861707500443 -0.2226907628250123
1.9134653074225207 1.1754945015148146 -0.20186835163116462
0.9820378971442002 1.0038122676280958 -0.15278330993652353
0.9820378971442002 0.91490424486198252 -0.13295851226806646
-1.7619973619500382 -0.0056919418521898359 0.069360218849182073
-1.7285430473748427 0.079494617176435647 0.042950982971191334
-1.7817873942986711 0.090815247640989485 0.0034371739196776261
-0.10272447544491105 0.049484021664045509 0.425941491317749
-0.10491544636165939 0.020295087480924782 0.39897834060668935
2.0079564390143174 0.16148264081992927 -0.82893760509490977
2.0079564390143174 0.24175324506797619 -0.93477608669281009
2.7019815571173447 0.18357597007789439 -0.92793097156524673
2.7019815571173447 0.082536094561002901 -0.83436181373596208
2.7050912897833608 -0.75061959730110339 -0.034326717720031791
0.92069474223697367 -0.70321840631447019 -0.73119780551910407
0.98397215892398515 -0.73160473081550781 -0.6764101807022096
5.1034443931158799 -0.41449343286476309 -0.94835427436828623
1.0273577665289659 0.84789169763603034 -0.88317792804718021
1.0274807047613876 0.66229892717399419 -0.88317792804718021
1.0076745493658799 0.66229899015464611 -0.77226175735473634
1.0075516111334581 0.84789169763603034 -0.77226175735473634
2.7050912897833608 -0.96378504522285646 -0.032131401138305732
-0.19061447895443281 0.17071872192420787 0.20172930004119866
-0.68049083713924741 0.18140701089896982 0.14096500030517575
-0.68049083713924741 0.14117141208686654 0.14096500030517575
-0.19085985157406157 0.1318966766075117 0.20189613578796375
-1.0877713454095108 -0.3701527394195574 0.2077718527221678
-2.1520582042351943 -0.45355718217811758 -0.21289991664886482
7.7828358073004509 0.49069359266319096 -0.79166811157226569
7.7854154948004508 0.45281671373405274 -0.69769134296417246
7.7854154948004508 0.4103165511135084 -0.71109309034347545
7.7828358073004509 0.42979086145438972 -0.81087280174255383
7.5401335673102166 1.111655801258467 1.7092159814453125
7.7626013834723251 1.111655801258467 1.7092159814453125
1.6732994242438095 -0.46551412191353014 -0.062116615447998097
-0.10272447544491105 0.049484021664045509 0.425941491317749
-0.16034698536312408 0.057933411445997403 0.42983432540893551
6.2236787284430282 -3.929174118709184 -0.22991413974761971
6.2591333085211529 -3.9126684013935105 -0.27012788427352913
0.98203688945377066 -0.12286045759021515 -0.88075197631835944
1.6732989203985944 -0.12286045762096742 -0.86112100160598759
-3.8400207930413468 -0.024867684540368865 -0.68233769922256471
-3.8417988628045299 -0.018957210158922017 -0.66729432966232305
2.0079564390143174 0.44536408723869148 -1.0007655132293702
-0.96180651478206924 0.19091976600684946 0.092354391860961824
-0.96180651478206924 0.14942609718360725 0.092354391860961824
-1.681421427501796 -0.12286045762096742 -0.8843718522644044
-2.1520587080804092 -0.1228604576517197 -0.88537859798431406
-1.021192231029628 0.26881502347984138 -0.48715876970291144
0.68032530559146587 -1.2063978526874561 -0.21743861732482919
0.81775211101138734 -1.2532787605091114 -0.21334944105148324
0.81775211101138734 -1.2162696919818896 -0.16931566806793216
0.68032530559146587 -1.1855309771533984 -0.18893102357864386
-1.0881489773980362 0.18772963853874033 0.10393514816284172
-1.0882552887383681 0.13970909582176036 0.097407014656066798
-1.087771597332118 0.12444116874732798 0.20777191570281972
4.5196278580816998 0.45974206621208014 -0.06201861755371104
7.7828358073004509 -0.27625978231392079 -0.41403621751785286
-1.0876448802605851 -0.41536247138939075 0.22344956340789793
-1.088148725475429 -0.43344119346580684 0.10393514816284172
5.4110338352545515 -4.4605801706501023 -0.25614873027801521
5.3977947983893166 -4.4298168933673878 -0.18729166870117195
-1.021192231029628 0.28786789878883184 -0.40672832056045544
7.7828358073004509 -0.29546423630676444 -0.60902378032684334
7.7828358073004509 -0.27625968784294302 -0.54571455841064465
7.7854144871100202 -0.37742184029541193 -0.5260559194469453
7.7854144871100202 -0.37742184029541193 -0.5260559194469453
7.7854144871100202 -0.39082344596824825 -0.5702354454040528
7.7828358073004509 -0.84589225580177474 -0.71851136089324963
7.7854144871100202 -0.77493239622078114 -0.646639856376648
6.4318998173102155 -1.4988220577045459 -0.56110378622055068
6.112183828540684 -1.5063103312488573 -0.50968660247802744
6.1403548221930278 -1.0246875874897021 -0.60189199301719676
6.4318998173102155 -1.0199561030384081 -0.61862373214721689
-2.4738706929436902 -0.46284134901008783 -0.64488461709976208
0.9820378971442002 -1.2495236021228806 -0.15278330993652353
-3.9326149473992569 -0.14339377000174694 -0.70903274129867566
2.0079564390143174 -0.89367044897041492 -0.99041596569061296
3.4010098582037709 0.82736882242240728 -0.81323920526504534
3.4010098582037709 0.82363318803825203 -0.57185640993118292
4.007016744190099 0.81059751569785898 -0.59435228002548224
1.6732994242438095 -1.2727939452930468 -0.089643631935119719
2.0079564390143174 -1.156135765590288 -0.052583108215332103
1.6732994242438095 -1.1765197684665698 -0.062827667007446339
5.2483109769781837 -4.4628782086750052 -0.19756141975402838
-3.6654485030022843 0.027985025072477517 -0.68797500289917002
-3.6684383205071667 0.037007759218595684 -0.66266666881561287
-3.4413512514153703 0.089537511921308696 -0.69351286012649549
3.4010098582037709 0.79609981050529299 -0.92236889827728274
7.2899824796637303 0.67674259496726807 -0.2588909708404542
7.2899824796637303 0.71175801096000491 -0.32443291984558115
7.0049008109625595 0.70958354097404308 -0.23095993347167976
-0.29427055500423749 -1.0630374511142748 -0.13451892089843759
-0.29427055500423749 -1.0692300866886157 -0.19189671949386608
-0.68015452045833924 0.14730128744163337 -0.7277292405891419
-1.021192231029628 0.14681605300941294 -0.72031603998184213
1.6732994242438095 -1.0338679622074145 -0.95940706386566177
1.6732994242438095 -1.1061837952228564 -0.86887599821090711
5.5084261075934178 -4.4162695032306685 -0.25775404411315922
5.4919654844244725 -4.3910339118000046 -0.31724493804931647
6.7631498307379498 0.059229852419279277 -0.1495086939239503
-3.1694531966057999 0.11862799160041637 -0.44121562804222109
-3.4269538744012102 -0.12286045759021515 -0.81534918306350712
-3.6559142400017959 -0.087568292927362262 -0.76866540468215949
-3.4274038081780653 -0.072434853162385779 -0.81155692907333388
6.4318998173102155 -0.19379609729728869 -0.22502923442840586
7.7854144871100202 -0.56245853883705321 -0.24912928470611584
7.7847504191168566 -0.54141723838768174 -0.14887857250213635
2.0079564390143174 -1.31272456029854 -0.079617049179077193
7.7847504191168566 -0.41976195333442862 -0.19926989589691166
7.7854144871100202 -0.47756304489097767 -0.28429415378570566
2.0079564390143174 0.33593016618766608 -0.9832248978424073
2.0079564390143174 0.91042430513419925 -0.052583108215332103
2.7050912897833608 0.89932944456138442 -0.043100363388061648
6.4318998173102155 0.050330355663679292 -0.12775454696655286
-0.68015452045833924 0.27928659603156875 -0.41169201467514044
7.7847504191168566 -0.88786262517891101 -0.29238090097427377
7.6574851639899029 -0.3728966962047594 -0.48011114028930674
7.7854144871100202 -0.3728966962047594 -0.48011114028930674
-1.6973535170403702 -0.38606075460395983 0.023096710357665889
-1.781786890453456 -0.3365268183132189 0.0034371739196776261
-1.7252126305047255 -0.38853454013786493 -0.048209605789184658
-1.6973535170403702 -0.38606075460395983 0.023096710357665889
1.6732994242438095 0.34184005012550184 -0.062932214889526425
0.9820378971442002 0.33758816333808722 -0.065793803787231528
6.4318998173102155 -1.0605938648029345 -0.28604092216491706
6.7631498307379498 -1.0486631250186937 -0.33460842035293592
6.7631498307379498 0.67324055582084474 -0.1498771307373048
0.75653189433658308 -0.22486142191372088 0.31317312263488756
0.69226946025455138 -0.28983381326637442 0.30514743518829346
0.71878280315005971 -0.31896913516960318 0.25687604053497304
0.75653189433658308 -0.22486142191372088 0.31317312263488756
-3.6626919658318737 0.013332970047376809 -0.71129928899765027
6.9963656730231065 -1.0088628169818896 -0.61255938816070565
7.7828358073004509 -1.3557899742694872 -0.60428903662681588
7.7828358073004509 -1.3557899742694872 -0.37123428310394296
7.2567780723150985 -1.3817814594837206 -0.35105651037216196
7.2567780723150985 -1.3758058552356738 -0.60514601435661319
7.7828358073004509 0.64215091280021486 -0.66737059923172004
7.2567790800055274 0.68433125967063724 -0.68043854915618907
0.81775211101138734 0.97055835748710462 -0.16931566806793216
0.81775211101138734 0.90638460016288569 -0.15347723075866709
0.9820378971442002 1.0038122676280958 -0.15278330993652353
3.4577992600592391 -2.7579982610126512 -0.27985908777236951
0.32608886577212964 0.12792546309509104 0.27205519638061521
-0.074266038097498946 0.16117639740028206 0.21722455577850341
-0.075138446087001334 0.11308337969817941 0.21755432247161849
0.32608886577212964 0.085460238991163437 0.27237967269897451
-1.0882164926568252 0.18694855249442879 0.084687694129943716
-1.0883205366936906 0.13904945221938914 0.079633055953979376
-0.96190753574764565 0.18192716810264414 0.22819647811889632
-0.9621045392266494 0.12584064606704537 0.34442997928619379
6.1403548221930278 -1.0588330517383593 -0.24311740360260017
6.9963656730231065 -0.37157838520012076 -0.81568842834472655
-0.96210428730404229 -0.37155218524894884 0.34442991630554193
-1.6973535170403702 -0.38606075460395983 0.023096710357665889
-1.6735579152337294 -0.34540664936027704 0.022757118682861219
6.2441076365240837 -4.0190895799823778 -0.23025086580276494
6.2861938273199822 -4.0344525763507857 -0.27057394474029545
6.1403558298834584 0.18022221887626472 -0.90581462287902847
3.4010098582037709 1.1476012525371533 -0.12085974010467541
-0.19061422703182526 -0.41643024536094841 0.20172923706054677
-0.19085959965145402 -0.37760821578941522 0.20189607280731187
6.7818102421149034 1.2033531111339553 -0.32231399879455574
6.7818112498053331 1.199388605060957 -0.61723337127685551
6.7818102421149034 -1.445099939555742 -0.61723330829620371
6.7818102421149034 -1.0168110382267015 -0.61547876180648808
1.6732994242438095 -1.1765197684665698 -0.062827667007446339
7.6574851639899029 0.1317103011135084 -0.52605596668243415
7.7854154948004508 0.1317103011135084 -0.52605596668243415
7.6574851639899029 0.59367407526054206 -0.43416603048324592
7.6574851639899029 0.59819929807700933 -0.48011121901512155
7.7854154948004508 0.59819929807700933 -0.4801112347602845
7.7854154948004508 0.59367407526054206 -0.43416604622840882
7.6574851639899029 0.55850914320030032 -0.61095199596405037
7.7854154948004508 0.55850914320030032 -0.61095199596405037
7.7854154948004508 0.58027235937156507 -0.57023590201377883
7.6574851639899029 0.58027235937156507 -0.57023590201377883
0.9820378971442002 -0.58329965528450189 -0.065793803787231528
0.9820378971442002 -0.74623576604805175 -0.065793803787231528
1.6732994242438095 -1.3932304602619188 -0.20102576498031627
1.6732994242438095 -1.353690577220537 -0.14345373405456555
2.0079564390143174 -0.40719416425666988 -0.82893751062393184
2.7019815571173447 -0.42928749351463485 -0.92793090858459482
2.0079564390143174 -0.48746476850471665 -0.9347760237121584
7.7828358073004509 -0.32665075931511095 -0.66737003240585335
7.7854144871100202 -0.41258653617820912 -0.61095157084465035
2.0079564390143174 -1.3550447871967335 -0.32811684711456307
1.6732994242438095 -1.3046551012989063 -0.32077994756698613
1.6732994242438095 -1.0936486301227588 -0.40009948099136361
7.6574851639899029 0.19616359806098765 -0.31358251867294318
7.7854154948004508 0.19616359806098765 -0.31358251867294318
7.7854154948004508 0.16687532764472787 -0.34927037908554087
7.6574851639899029 0.16687532764472787 -0.34927037908554087
7.6574851639899029 0.14511207998313727 -0.38998648878097542
7.7854154948004508 0.14511207998313727 -0.38998648878097542
7.7854154948004508 0.13171039558448619 -0.43416598324775701
7.6574851639899029 0.13171039558448619 -0.43416596750259401
7.6574851639899029 0.40863742395438973 -0.24912928470611584
7.7854154948004508 0.40863742395438973 -0.24912928470611584
7.7854154948004508 0.36269225116767706 -0.24460406188964851
7.6574851639899029 0.36269225116767706 -0.24460406188964851
7.7854154948004508 0.19616340911903205 -0.64663960445404056
7.6574851639899029 0.19616340911903205 -0.64663960445404056
7.7854154948004508 0.23185126953162974 -0.67592796934127808
7.7828358073004509 0.1740501149944288 -0.76048119493484512
7.7854154948004508 0.59367407526054206 -0.52605640754699712
7.6574851639899029 0.59367407526054206 -0.52605640754699712
7.7854154948004508 0.59367407526054206 -0.52605640754699712
7.7854154948004508 0.58027235937156507 -0.57023590201377883
7.7828358073004509 0.67333754602470219 -0.60902447311401375
7.6574851639899029 0.36269199924506967 -0.71561825017929082
7.7854154948004508 0.36269199924506967 -0.71561825017929082
7.7854154948004508 0.4103165511135084 -0.71109309034347545
7.6574851639899029 0.4103165511135084 -0.71109309034347545
7.6574851639899029 0.3167468579486829 -0.71109299587249764
7.7854154948004508 0.3167468579486829 -0.71109299587249764
7.7828358073004509 0.64215091280021486 -0.66737059923172004
7.7854154948004508 0.55850914320030032 -0.61095199596405037
7.7854154948004508 0.45281671373405274 -0.69769134296417246
7.6574851639899029 0.45281671373405274 -0.69769134296417246
7.6574851639899029 0.58027254831352049 -0.38998652027130137
7.7854154948004508 0.58027254831352049 -0.38998652027130137
7.7854154948004508 0.55850926916160404 -0.34927037908554087
7.6574851639899029 0.55850926916160404 -0.34927037908554087
-0.2314574316827043 0.28808241088905162 -0.33334575275421147
5.4919654844244725 4.1453223253826126 -0.31724493804931647
5.3955325333746682 4.1841053069499949 -0.32453230331420907
5.4110348429449822 4.2148680803874958 -0.25614873027801521
5.5084261075934178 4.1705579168132765 -0.25775404411315922
7.7828358073004509 0.3615449011425001 -0.8173573211479187
7.7854154948004508 0.36269199924506967 -0.71561825017929082
7.6574851639899029 0.27256763114967175 -0.26253096910476686
7.7854154948004508 0.27256756816901984 -0.26253096910476686
7.7854154948004508 0.23185155294456308 -0.28429418527603156
7.6574851639899029 0.23185155294456308 -0.28429415378570566
2.7019815571173447 -1.4547279177661914 -0.31837906213760386
2.9421887556036723 -1.4568530109210986 -0.3352931145095826
7.7854154948004508 0.27256756816901984 -0.26253096910476686
7.7847514268072855 0.23239658750572029 -0.16808326267242443
7.7854154948004508 0.27256731624641245 -0.69769121700286874
7.6574851639899029 0.27256737922706425 -0.69769121700286874
7.6574851639899029 0.23185126953162974 -0.67592796934127808
7.7854154948004508 0.23185126953162974 -0.67592796934127808
6.4318998173102155 -1.4988220577045459 -0.56110378622055068
6.1687112308844343 -1.5064097147174851 -0.31582220512390147
6.1433265012701757 -1.506391450328447 -0.34498328611373913
6.112183828540684 -1.5063103312488573 -0.50968660247802744
7.6574851639899029 0.12718515702285593 -0.48011114028930674
7.7854154948004508 0.12718512553253 -0.48011115603446969
7.9833480643805288 -1.2595740545459764 1.7092159814453125
7.7854154948004508 0.52922087278404062 -0.31358251867294318
7.6574851639899029 0.52922087278404062 -0.31358251867294318
-3.139896628612636 0.1444134356121046 -0.69136660547256479
-0.19061422703182526 -0.41643024536094841 0.20172923706054677
-0.19503395725643449 -0.41488847900352654 0.23514960506439198
-0.19354635425960831 -0.37627039652786431 0.22275060413360584
-0.19085959965145402 -0.37760821578941522 0.20189607280731187
-2.7961452077141984 0.11855839798011608 -0.78770020454406742
7.7854154948004508 0.16687532764472787 -0.34927037908554087
7.7854154948004508 0.19616359806098765 -0.31358251867294318
7.7847514268072855 0.12290958951034371 -0.24124013931274424
7.7847514268072855 0.080939472055814921 -0.29238093246459967
7.7828358073004509 0.49069359266319096 -0.79166811157226569
7.7854154948004508 0.14511207998313727 -0.38998648878097542
7.7847514268072855 0.049752807341001674 -0.3507269956016541
7.7854154948004508 0.23185155294456308 -0.28429418527603156
7.7847514268072855 0.17405049287833996 -0.19926989589691166
2.9421887556036723 -1.4568530109210986 -0.3352931145095826
3.4010098582037709 -1.4556685967823046 -0.36178214687347421
-0.96224536396419846 0.025690482473753152 0.43291231582641587
-1.021192231029628 0.022634787207029522 0.42667395629882809
-1.0211917271844131 -0.12286032074260735 0.46070958229064934
-0.96230557346737222 -0.12286041183083529 0.46814318862915033
6.1403558298834584 0.11190290185012645 -0.8768211334037781
6.4318998173102155 0.18460466455497568 -0.88269486644744877
-2.1520582042351943 -0.21102321074447805 -0.87707198534011854
0.98397215892398515 0.51768911542930429 -0.6764102436828614
0.98397215892398515 0.48589327035941904 -0.6764102436828614
7.6574851639899029 0.3167471098712904 -0.24912928470611584
7.7854154948004508 0.31674704689063848 -0.24912928470611584
7.7828358073004509 0.080939220133207479 -0.66737009538650527
7.7854154948004508 0.16687507572212046 -0.61095163382530226
4.007016744190099 -1.0146565960880296 -0.92040327213287354
4.007016744190099 -0.96193473665199447 -0.96425638511657719
7.7828358073004509 0.12290936907806221 -0.71851095151901256
7.7854154948004508 0.19616340911903205 -0.64663960445404056
7.7854154948004508 0.52922087278404062 -0.31358251867294318
7.7854154948004508 0.55850926916160404 -0.34927037908554087
7.7847514268072855 0.64215103876151858 -0.29238093246459967
7.7847514268072855 0.60018092130698975 -0.24124013931274424
3.9465301261481067 -1.1289019870182055 -0.15114568702697764
-0.68015452045833924 0.19694799058952156 -0.64823241662979136
-0.68015452045833924 0.23420236875572034 -0.56962527310371402
-0.68015452045833924 0.26269330411948982 -0.49117802170753488
7.0049008109625595 0.65769497854270753 -0.16756694728851329
7.7847514268072855 0.64215103876151858 -0.29238093246459967
-0.21923263523495026 -0.22030578731498893 0.42448298538207996
-0.22125229877865171 -0.12298269688501234 0.44246295379638656
0.81775211101138734 -1.2162696919818896 -0.16931566806793216
0.81775211101138734 -1.1520959346576709 -0.15347723075866709
-0.29427055500423749 -1.0630374511142748 -0.13451892089843759
-3.8343540459099992 -0.10056280544362242 -0.7303003942108155
1.6732994242438095 -0.21039711221180138 -0.85636441936492935
7.6574851639899029 -0.8259840087696092 -0.38998648878097542
7.7854144871100202 -0.8259840087696092 -0.38998648878097542
6.1403558298834584 0.72787236650504894 -0.80840219673156744
6.1403558298834584 0.65035105665244886 -0.87820245655059814
2.0079564390143174 -1.0338679622074145 -0.97629708911895763
2.7050912897833608 -0.35501264732322868 -0.019435257492065483
0.80393113292300888 0.89092026792564227 -0.28889564617156993
0.81775211101138734 0.94958479272880381 -0.2655011996269227
-2.4738711967889055 -0.12286045762096742 -0.8865359304428102
-2.8521647340813856 0.1185583822349531 -0.31358569919586193
-3.1742266261712291 0.0839266443733198 -0.40081399648666394
-3.1781445265618546 0.041642946253202598 -0.36765701356887825
-2.8570913325921277 0.069273817835233842 -0.27189294853210455
0.37424387218082106 0.33758816333808722 -0.089407958335876572
3.4010098582037709 0.82363318803825203 -0.57185640993118292
2.7019815571173447 0.83455365518607916 -0.52692824871063237
2.7019815571173447 1.2090165832714064 -0.31837906213760386
2.9421887556036723 1.2111416764263134 -0.3352931145095826
3.4010098582037709 1.2099572622875197 -0.36178214687347421
3.4010098582037709 1.2099572622875197 -0.36178214687347421
3.4010098582037709 -1.0693446484943407 -0.57185636269569406
7.7847514268072855 0.17405049287833996 -0.19926989589691166
7.7847514268072855 0.23239658750572029 -0.16808326267242443
7.2899824796637303 0.21732947423972909 -0.12135911369323739
7.7828358073004509 -0.36862089251480273 -0.71851088853836076
-0.9621045392266494 0.12584064606704537 0.34442997928619379
-1.021192231029628 0.12160033197440928 0.34086754169464112
-1.021192231029628 0.022634787207029522 0.42667395629882809
-0.96224536396419846 0.025690482473753152 0.43291231582641587
-0.2314574316827043 0.29108655649223153 -0.24895007326126109
6.9963656730231065 -0.52449720285377677 -0.8790297074127198
7.8612452073248633 -0.1228604278527687 -0.55936955099105845
7.8612452073248633 -0.12286035217142875 -0.43482630389213567
-0.21488848179256759 0.037667717724226175 0.39057924087524404
-0.68015452045833924 0.080367324324033901 0.3706996500396727
-0.21923288715755782 -0.025405775484659027 0.42448298538207996
7.7828337919195896 -0.1228603207118551 -0.37601596313476571
7.8234739469488872 -0.20762744357547935 -0.45583694850921641
7.8612452073248633 -0.12286035217142875 -0.43482630389213567
-0.22447791584408125 -0.23515393259964162 0.4681258059692382
-0.21923263523495026 -0.22030578731498893 0.42448298538207996
7.7828358073004509 -0.93825375963173085 -0.54571517247200019
5.1173102134283797 0.62050175458946044 -0.089276202812194949
0.68135365367496148 -1.1328882843967456 -0.26290044509887706
0.55112830791080192 -1.1288845413776414 -0.21765942749023448
0.33638141582095793 -1.1031546777912156 -0.45456061410903936
-0.22618897419369019 -0.12299817351914222 0.48244596870422352
-0.22125229877865171 -0.12298269688501234 0.44246295379638656
0.9820378971442002 -0.26960420745811636 -0.85929569635391245
7.7828358073004509 -0.54141695497474851 -0.81087258131027229
7.7828358073004509 -0.4781077645488756 -0.79166789113998426
7.7854144871100202 -0.51827877670250111 -0.69769115402221693
7.7854144871100202 -0.56245831840477167 -0.71109293289184572
0.3346900074347276 -0.12286045759021515 -0.88881759349823009
-0.23145717976009675 -0.24030246705494099 -0.86282450227737439
-0.23145793552791871 -0.1228604576517197 -0.87766850658416762
-0.9621045392266494 0.092953739929578949 0.31745454734802231
-0.96190753574764565 0.14162279441871467 0.21659304878234856
6.4318998173102155 0.1205756367687208 -0.85376763261795041
7.0067610074957623 -1.2259747585102099 -0.28011951276779185
7.0049008109625595 -1.1303875116535202 -0.35782173454284677
5.0012494681891226 -4.3540567114826212 -0.24939427579879772
0.68032530559146587 -1.1855309771533984 -0.18893102357864386
0.68032530559146587 -1.1412733394428272 -0.17682100936889658
7.7847514268072855 0.67333767198600591 -0.35072705858230602
-3.6568211613885144 -0.05782442441187078 -0.76098818918228162
-3.428730936473964 -0.030742527618028464 -0.8003257783699036
7.7847514268072855 0.29570577793159314 -0.14887857250213635
7.2899824796637303 0.28914420169868293 -0.099916028175354055
6.4318998173102155 0.62907581457176032 -0.86019619371414191
5.1173102134283797 0.36639922935523805 -0.019671812820434658
4.5196278580816998 0.74831355581321535 -0.91656189323425308
-2.4738706929436902 -0.20464686848125632 -0.87901434013366708
1.0272519590338489 -0.61499435342750719 -0.88317786506652851
1.0589423115118759 -0.60723951427421752 -0.89902304130554211
6.9963656730231065 0.76315148248710452 -0.61255945114135757
7.7847504191168566 -0.47810811094246081 -0.16808326267242443
7.7854144871100202 -0.51827902862510855 -0.26253096910476686
-0.11164455112850524 -0.12295222384422297 0.43906804473876943
-3.8348936641350964 -0.081078565809346984 -0.72573706809997562
3.4045287131842397 -0.27311232423744375 -0.043913065719604578
-3.665447999157069 -0.27369659574470695 -0.6879749399185181
-0.219516552013515 0.062128662882230921 0.42798823654174795
-0.21488848179256759 0.037667717724226175 0.39057924087524404
-0.21923288715755782 -0.025405775484659027 0.42448298538207996
-0.22447816776668883 -0.010557638072587789 0.4681258059692382
0.84229844218814531 -0.12286045762096742 0.32026531085968019
0.78435170787418074 -0.1228658323184515 0.3344353907012938
7.2834385380133408 -1.2302770927997606 -0.28156151777267463
7.2899814719733023 -1.1164500193592088 -0.37458154729843146
6.1403548221930278 -0.23444409341774161 -0.16008906555175789
6.1403548221930278 -0.18979447200260338 -0.19255842571258552
5.7686903763922466 -0.19808195427379782 -0.17142602375030525
5.7686903763922466 -0.24143827587566549 -0.1635095447540284
6.1403548221930278 -0.23444409341774161 -0.16008906555175789
6.1403548221930278 -0.97358388994178957 -0.80840216524124153
6.1403548221930278 -0.89606258008918926 -0.87820239356994645
5.7971294156988868 0.60581183244743164 -0.91520100730896015
7.6574851639899029 -0.73924447282753158 -0.67592815828323372
7.7854144871100202 -0.73924447282753158 -0.67592815828323372
-1.8379051704827529 -0.1228604576517197 0.060776900711059512
-1.7779319707146866 -0.12286067276385823 0.090953954086303579
-3.4696648332635149 0.0076812752918226056 -0.45388195034980783
5.9446049100836529 -4.1676412877460498 -0.22162292587280283
-2.1520582042351943 -0.40616049430809198 -0.14739008777618415
4.5196278580816998 -1.1222159610172289 -0.18717672901153573
6.1403558298834584 0.65035105665244886 -0.87820245655059814
6.1403558298834584 0.55234428209342779 -0.90287178894042974
7.7854144871100202 -0.83938566167793438 -0.43416601473808297
7.7828358073004509 -0.93825375963173085 -0.41403634347915658
6.1403558298834584 -0.011267469381906332 -0.16008906555175789
6.9963656730231065 1.165915522251509 -0.33001927217483529
6.9963666807135354 1.1595336927989943 -0.61498326152801519
-0.2942708069268451 0.36152780189552136 -0.18747906763076791
-0.2942708069268451 0.36152780189552136 -0.11604587696075447
7.2567790800055274 0.73791733961143313 -0.58375728114128123
7.2899824796637303 0.87073855890312013 -0.37458154729843146
7.2834385380133408 0.98456601022758305 -0.28156151777267463
7.2834385380133408 0.98456601022758305 -0.28156151777267463
3.4010098582037709 0.74047277956046875 -0.96495647804260265
4.007016744190099 0.71622340215720948 -0.9642564480972291
7.7854144871100202 -0.8259840087696092 -0.38998648878097542
7.7847504191168566 -0.91904913244209463 -0.35072705858230602
7.9833480643805288 -1.2595740545459764 1.7092159814453125
7.8601962015875602 -1.2595738026233689 -0.25392548177719121
6.1403558298834584 0.042391235123060388 -0.12134998149871835
0.98397215892398515 -0.76281706014595207 -0.27662654283523563
0.98397215892398515 -0.73160460485420398 -0.27678257740020756
0.98397215892398515 -0.73160454187355217 -0.45805097034454351
0.98397215892398515 0.7027257037548047 -0.28022938251495372
0.98397215892398515 0.65403725122489753 -0.28138532939910899
4.5196278580816998 -0.41709664363823107 -0.95911244037628174
0.33638141582095793 -1.1031546777912156 -0.45456061410903936
-0.29427055500423749 -1.0692300866886157 -0.19189671949386608
7.2567790800055274 0.0093252907375318255 -0.61452649435043349
7.7828358073004509 0.049752681379697981 -0.6090238590526581
1.0023070862921493 0.88769899652519046 -0.31742767641067515
1.3084782041510363 1.0206900746349317 -0.30242247312545789
1.3132758182867783 0.87521856161155531 -0.35444376728057869
2.0079564390143174 0.8479372326473219 -0.4424360828590394
-0.092189072002528238 -0.37102949307403743 0.35128428958892804
8.6453261075934176 -1.2999478014179247 -0.43719810800552378
8.6453261075934176 -1.2999478014179247 -0.53871743947982798
6.9963656730231065 0.061583754282377424 -0.76293252786636367
-3.4308858824578508 0.0076812831644040916 -0.78208733736038216
1.0023070862921493 0.88769899652519046 -0.31742767641067515
1.6732994242438095 0.84793710668601818 -0.40009951248168951
1.6732994242438095 1.0589440187267285 -0.32077997905731209
7.7854154948004508 0.58027254831352049 -0.38998652027130137
7.7847514268072855 0.67333767198600591 -0.35072705858230602
1.9134653074225207 -1.4212058360095996 -0.20186835163116462
2.0079564390143174 -1.3968683486743945 -0.14016620700836188
6.4318998173102155 0.62907581457176032 -0.86019619371414191
0.33627510448062559 -0.6072394512935656 -0.45456061410903936
6.7818102421149034 -0.44462904497108635 -0.86051201019287127
5.325728809619787 -4.4848226831623093 -0.25474265573501592
5.2365995988043563 -4.4894112015338914 -0.25327353755950938
5.2464679111822861 -4.4628782086750052 -0.30934133859634411
5.3236015751227157 -4.4573757150836961 -0.31673951831817637
-0.96183976856624931 0.15000914056815925 0.10435598487853995
7.8612452073248633 -0.12286035217142875 -0.43482630389213567
7.8612452073248633 -0.1228604278527687 -0.55936955099105845
-0.20900961582577057 0.13787673673667733 0.34467213989257806
-0.20566156437313385 0.10339805760421579 0.31791273159027084
-0.2314574316827043 -0.0054091036172884219 -0.86282456525802609
6.1403558298834584 0.81312159128227046 -0.24311740360260017
0.98397215892398515 0.64756743780174075 -0.67641014921188358
0.9209234879645124 0.66233054346122566 -0.73119771104812636
-0.96210428730404229 -0.37155218524894884 0.34442991630554193
-0.96224511204159091 -0.27140205314598254 0.43291218986511226
7.2899824796637303 0.75170972448386975 -0.38360484827041635
0.9208630265387312 -0.99884996400795156 -0.73119827787399305
0.98397215892398515 -0.96495667428932363 -0.67641055858612065
2.7050912897833608 0.10930110814132518 -0.019435257492065483
2.7050912897833608 0.22610954393424812 -0.039333679542541557
1.6732994242438095 0.26278708231010267 -0.84805267379760751
-0.092189323925135805 0.1253179538921339 0.35128435256957996
6.1403558298834584 -0.020631849946595983 -0.76802337991714487
6.1403558298834584 -0.020631849946595983 -0.76802337991714487
-1.082313442119716 -0.12286023786523589 0.43227117279052724
-1.0832619307366593 0.011093661480329694 0.40297332931518548
-1.7509742363396865 -0.12311901555373544 0.085419592285156151
-1.0826484991875871 -0.12311938310488336 0.40060702026367173
-1.0835604590264543 -0.0094645931144731795 0.37355229568481446
-1.7356654033318741 -0.023640482921220608 0.065478910217285025
6.9963656730231065 -0.44491859851799187 -0.85488966442108161
8.0291737943609967 0.81472174070396253 -0.57406317324638378
8.0291737943609967 0.81472174070396253 -0.40371362569808972
7.7828358073004509 0.75044475809135269 -0.39515657049179087
7.7828358073004509 0.75044475809135269 -0.60464665651321414
-0.96180651478206924 0.19091976600684946 0.092354391860961824
-0.96180651478206924 0.14942609718360725 0.092354391860961824
6.7818102421149034 -1.4490644456287403 -0.32231399879455574
6.7786037711676377 -1.3758098859973924 -0.31597175268173222
6.1393955009039658 -1.5064278531452198 -0.2866611241340638
6.1687112308844343 -1.5064097147174851 -0.31582220512390147
6.4318998173102155 -1.4988220577045459 -0.56110378622055068
6.4318998173102155 -1.4988220577045459 -0.56110378622055068
6.4318998173102155 -1.4961088512226124 -0.28979611204147349
6.1393955009039658 -1.5064278531452198 -0.2866611241340638
-0.29427055500423749 -0.60723929384193598 -0.18747906763076791
-0.29427055500423749 -0.60723929384193598 -0.11604587696075447
-1.735664899486659 -0.22207108775100884 0.065478910217285025
-1.0835602071038466 -0.23624696181259328 0.37355223270416255
5.7349559238775987 -1.299198205699541 -0.23880644096374523
5.7829098960455676 -1.2565944399066942 -0.24123547874450688
6.2441076365240837 -4.0190895799823778 -0.23025086580276494
7.7828358073004509 -0.36862089251480273 -0.71851088853836076
7.7854144871100202 -0.44187486957512073 -0.64663954147338876
-1.6973540208855851 0.14034927840270822 0.023096710357665889
-1.7252131343499406 0.14282301670112438 -0.048209605789184658
-1.7817873942986711 0.090815247640989485 0.0034371739196776261
-1.6973540208855851 0.14034927840270822 0.023096710357665889
-0.68015452045833924 -0.0062496827598589079 -0.85868774412155158
-1.680498886913417 -0.41346325834236319 -0.084491940574646068
-1.6812234163323623 -0.46680746108970811 -0.15552114185333263
-1.0211919791070208 -0.45480016832313708 0.0025802591705321723
-0.22618897419369019 -0.12299817351914222 0.48244596870422352
-0.22447816776668883 -0.010557638072587789 0.4681258059692382
0.98397215892398515 -0.73160460485420398 -0.27678257740020756
6.1433265012701757 -1.506391450328447 -0.34498328611373913
6.1687112308844343 -1.5064097147174851 -0.31582220512390147
5.797128408008458 -0.99438413194618402 -0.83857830539703382
6.7818102421149034 -1.0168110382267015 -0.61547876180648808
-1.0882164926568252 0.18694855249442879 0.084687694129943716
-1.6973540208855851 0.14034927840270822 0.023096710357665889
-1.6735584190789443 0.099695110178373514 0.022757118682861219
-1.0883205366936906 0.13904945221938914 0.079633055953979376
0.98397215892398515 -0.94843710123024161 -0.28022938251495372
0.98397215892398515 -0.89974871168098625 -0.28138532939910899
7.5401335673102166 1.111655801258467 1.7092159814453125
7.5697385044440049 1.0534871231273635 1.7761082356262203
-1.082313442119716 -0.12286023786523589 0.43227117279052724
-1.0832616788140519 -0.25680523215255913 0.40297332931518548
0.81775211101138734 1.0075674260143261 -0.21334944105148324
8.6453261075934176 -1.2999478014179247 -0.43719810800552378
7.9164716813238876 -1.299198205699541 -0.25791036209106455
7.8621853824957624 -1.338822104930498 -0.22332132511138925
-0.093891816906092551 0.083294035215757567 0.33408370674133286
7.7828358073004509 -0.27625978231392079 -0.41403621751785286
7.7847514268072855 0.049752807341001674 -0.3507269956016541
5.7971294156988868 0.74867267149009531 -0.83857836837768573
-0.092189323925135805 0.1253179538921339 0.35128435256957996
-0.15000858539974546 0.133689263410948 0.34953890678405752
1.6732994242438095 0.21980259847678965 -0.062116615447998097
7.7828358073004509 -0.9961562185474413 -0.60464659353256234
7.7828358073004509 -0.9961562185474413 -0.39515653900146491
1.0272519590338489 0.36928292446174449 -0.88317792804718021
7.2567790800055274 1.1300945207408888 -0.60514607733726511
7.2567790800055274 1.1360701249889356 -0.35105651037216196
6.4318998173102155 0.81488246732749769 -0.28604092216491706
6.4318998173102155 0.9035238929943068 -0.29576831533432019
-0.1343470607415419 0.84734641115226572 -0.12775146091461187
-0.092189072002528238 -0.37102949307403743 0.35128428958892804
4.5196278580816998 0.17138512020149058 -0.95911250335693365
7.7828358073004509 0.030548227386854351 -0.4140362490081787
7.7828358073004509 -0.88786249921760729 -0.66737053625106824
4.007016744190099 -1.0563089761539477 -0.59435224853515634
-1.0882162407342177 -0.43266010742149524 0.084687631149291911
-1.0883202847710831 -0.38476095991096665 0.079633055953979376
-1.6735579152337294 -0.34540664936027704 0.022757118682861219
-1.6973535170403702 -0.38606075460395983 0.023096710357665889
5.7349559238775987 -1.299198205699541 -0.23880644096374523
5.7900191520270132 -1.3425440095325487 -0.24544513700485235
2.0079564390143174 -1.3968683486743945 -0.14016620700836188
7.7828358073004509 -1.1181879074665086 -0.38074634542465219
7.8601962015875602 -1.2595738026233689 -0.25392548177719121
7.7828358073004509 -0.29546423630676444 -0.60902378032684334
7.6574851639899029 -0.83938566167793438 -0.52605636031150826
0.33469051127994204 0.02339486920394724 -0.86452312194824221
5.4110338352545515 -4.4605801706501023 -0.25614873027801521
5.3955325333746682 -4.4298168933673878 -0.32453227182388317
0.9209234879645124 0.66233054346122566 -0.73119771104812636
0.98397215892398515 0.71924527681388684 -0.67641062156677256
0.9208630265387312 0.75313862951316657 -0.73119834085464486
-0.68015426853573169 -0.41843246326408556 0.073937463684081953
-1.0211919791070208 -0.42826638820610224 0.024631170959472582
-1.7779319707146866 -0.12286067276385823 0.090953954086303579
7.7828358073004509 -0.41976157545051745 -0.7604811319541932
7.7854144871100202 -0.47756272998771843 -0.67592790636062627
5.797128408008458 -0.23371798948249992 -0.80707065979003922
0.69226946025455138 0.044122242594144996 0.30514749816894515
0.69226946025455138 0.044122242594144996 0.30514749816894515
4.0095727509650008 -0.12286045759021515 -0.047715207672119231
-1.0832619307366593 0.011093661480329694 0.40297332931518548
-1.021192231029628 0.12160033197440928 0.34086754169464112
-1.0856982742730361 0.10682231564559763 0.32807226650238031
-0.96183976856624931 0.15000914056815925 0.10435598487853995
-0.96180651478206924 0.14942609718360725 0.092354391860961824
7.8601962015875602 1.0138627200511914 -0.25392548177719121
7.9833480643805288 1.0138629719737988 1.7092159814453125
1.6732994242438095 -0.4913323473545092 -0.77370700586318975
1.6732994242438095 -0.50849860574684314 -0.8480526108169556
1.0589423115118759 -0.60723951427421752 -0.89902304130554211
1.0589423115118759 -0.60723951427421752 -0.89902304130554211
1.6732994242438095 -0.4913323473545092 -0.77370700586318975
7.7828358073004509 0.75044475809135269 -0.60464665651321414
7.7828358073004509 0.69254229917564214 -0.54571521970748915
7.2567790800055274 0.73791733961143313 -0.58375728114128123
-0.20900961582577057 0.13787673673667733 0.34467213989257806
-0.219516552013515 0.062128662882230921 0.42798823654174795
6.7631498307379498 -0.045292113122560332 -0.2683001227760316
-0.2056613124505263 -0.3491095967861193 0.31791266860961914
-0.21488822986996003 -0.28337925690612964 0.39057924087524404
2.0079564390143174 -1.4322122087665574 -0.25337717222213757
0.9208630265387312 -0.99884996400795156 -0.73119827787399305
0.98397215892398515 -0.97150414285621822 -0.45872848470687871
0.98397215892398515 -0.96495667428932363 -0.67641055858612065
-0.2942708069268451 0.8173259276775342 -0.13451892089843759
0.98397215892398515 -0.73160473081550781 -0.6764101807022096
6.1403558298834584 1.1184739606670362 -0.28365304224014293
6.7530910648688094 0.97663271539726082 -0.27203304899215702
-0.10982466221248903 -0.035383020772554223 0.4287188121032714
-0.10741678593075105 -0.017537555412866418 0.46015623428344715
1.6732994242438095 -0.50849860574684314 -0.8480526108169556
7.7828358073004509 -0.91904900648079091 -0.60902441013336184
-1.7356654033318741 -0.023640482921220608 0.065478910217285025
-1.0835604590264543 -0.0094645931144731795 0.37355229568481446
-1.0859013238946182 0.071380756817243735 0.3043853063201904
-1.7035241093865616 0.048301811848066492 0.041091542205810419
7.7828358073004509 0.69254229917564214 -0.41403637496948253
6.2861938273199822 -4.0344525763507857 -0.27057394474029545
6.2441076365240837 -4.0190895799823778 -0.23025086580276494
1.6732994242438095 -0.4913323473545092 -0.77370700586318975
1.6732994242438095 -0.40765414344749623 -0.78356602859497071
6.9963656730231065 -1.411626856746294 -0.33001924068450939
2.0079564390143174 0.86047246072807138 -0.88576599197387706
7.7828358073004509 -0.29546423630676444 -0.60902378032684334
-1.0883202847710831 -0.38476095991096665 0.079633055953979376
-1.6735579152337294 -0.34540664936027704 0.022757118682861219
-1.0859013238946182 0.071380756817243735 0.3043853063201904
-1.6735584190789443 0.099695110178373514 0.022757118682861219
7.3509114738043566 1.0534871231273635 1.7761082356262203
7.3690035477789655 1.0138630979351027 1.7092159814453125
7.5401335673102166 0.99531831903495604 1.7092159814453125
7.5697385044440049 1.0534871231273635 1.7761082356262203
8.6453271152838482 0.94968190889396487 -0.53876667460441596
8.6453271152838482 0.94968190889396487 -0.43775429014205935
0.55112830791080192 -1.1288845413776414 -0.21765942749023448
6.4702625919684191 0.97229511194267093 -0.25518991283416759
7.8621853824957624 1.093110770435713 -0.22332132511138925
7.9833480643805288 1.0931110223583205 1.7092159814453125
7.2899824796637303 0.87073855890312013 -0.37458154729843146
7.5697385044440049 1.0534871231273635 1.7761082356262203
6.7631498307379498 0.80295179052390864 -0.33460845184326182
8.0445451041754499 -1.2991984576221483 1.7761079837036136
5.7349559238775987 1.053486871204756 -0.23880644096374523
5.7829109037359965 1.0108831054119092 -0.24123547874450688
7.3690035477789655 1.0931110223583205 1.7092159814453125
7.3509114738043566 1.0534871231273635 1.7761082356262203
7.7828358073004509 -0.9961562185474413 -0.60464659353256234
8.0291737943609967 -1.0604332011600512 -0.40371359420776376
8.6453261075934176 -1.19539324338875 -0.43775425865173351
8.6453261075934176 -1.19539324338875 -0.53876664311409006
7.7828358073004509 -0.9961562185474413 -0.39515653900146491
-0.13445211246883712 -0.58336802078209093 -0.10927847995758065
1.6732994242438095 -0.46551412191353014 -0.062116615447998097
2.0079564390143174 -0.40719416425666988 -0.82893751062393184
7.6574851639899029 -0.8259840087696092 -0.38998648878097542
7.6574851639899029 -0.4125867881008165 -0.34927037908554087
7.6574851639899029 -0.44187505851707631 -0.31358248718261728
7.6574851639899029 -0.65434888441047845 -0.24912928470611584
7.6574851639899029 -0.6985284261127489 -0.26253096910476686
0.78435170787418074 -0.1228658323184515 0.3344353907012938
7.6574851639899029 -0.7392445358081835 -0.28429415378570566
7.7828358073004509 -0.93825375963173085 -0.41403634347915658
0.33627510448062559 -0.70321840631447019 -0.45456061410903936
8.6453261075934176 -1.19539324338875 -0.43775425865173351
2.0079564390143174 -1.4322122087665574 -0.25337717222213757
1.9134653074225207 -1.4212058360095996 -0.20186835163116462
1.6732994242438095 -1.3932304602619188 -0.20102576498031627
6.1433265012701757 -1.506391450328447 -0.34498328611373913
0.92069474223697367 -0.70321840631447019 -0.73119780551910407
-0.20538747257625914 -0.97792155637703115 -0.22928017650604252
-0.20538747257625914 -0.97792155637703115 -0.22928017650604252
0.33793628215396604 -1.007144893741228 -0.45541894592285159
0.67819353648746172 -1.1358316221805589 -0.096073956489563073
1.6732994242438095 -1.1765197684665698 -0.062827667007446339
1.0590481190069931 -1.0936030321308152 -0.89902304130554211
1.0590481190069931 -1.0936030321308152 -0.89902304130554211
0.55112830791080192 -1.1288845413776414 -0.21765942749023448
0.55112830791080192 -1.1288845413776414 -0.21765942749023448
-0.29427055500423749 -0.60723929384193598 -0.18747906763076791
0.55112830791080192 0.88317308092155278 -0.21765942749023448
0.37434917583072386 -1.1204320340534228 -0.10788100227355969
-0.1343470607415419 -1.0930578716083545 -0.12775146091461187
-0.29427055500423749 -1.0630374511142748 -0.13451892089843759
-0.29427055500423749 -1.0692300866886157 -0.19189671949386608
0.68032530559146587 -1.1412733394428272 -0.17682100936889658
0.81775211101138734 -1.1520959346576709 -0.15347723075866709
0.67819353648746172 -1.1358316221805589 -0.096073956489563073
0.9820378971442002 -1.154106906871416 -0.084266910705566453
1.0272519590338489 -0.61499435342750719 -0.88317786506652851
1.6732994242438095 -0.58755160505256832 -0.062932277870178313
5.7349559238775987 1.053486871204756 -0.23880644096374523
5.7900191520270132 1.0968325490764601 -0.24544513700485235
7.6574851639899029 -0.44187486957512073 -0.64663954147338876
7.6574851639899029 -0.82598394578895729 -0.57023585477828986
7.7828358073004509 -1.3557899742694872 -0.37123428310394296
7.6574851639899029 -0.56245860181770502 -0.24912928470611584
7.6574851639899029 -0.39082357192955192 -0.38998645729064946
0.9208630265387312 -0.99884996400795156 -0.73119827787399305
-0.2942708069268451 0.36152780189552136 -0.18747906763076791
0.3340153586920514 0.3216977669910413 -0.37441342044830328
-1.7356654033318741 -0.023640482921220608 0.065478910217285025
-0.20589282932674685 -0.70321828035316636 -0.22491344449996956
7.6574851639899029 -0.51827883968315291 -0.69769115402221693
7.6574851639899029 -0.47756272998771843 -0.67592790636062627
7.6574851639899029 -0.60840371162376583 -0.24460406188964851
5.2365995988043563 4.2436996151164994 -0.25327353755950938
5.2464689188727158 4.2171666222576123 -0.30934137008667001
5.1862513541754502 4.189607800541304 -0.30834879501342782
5.1602972794684181 4.2095076711467723 -0.25201584543228162
7.7828358073004509 -0.93825375963173085 -0.54571517247200019
-1.6735584190789443 0.099695110178373514 0.022757118682861219
-1.6973540208855851 0.14034927840270822 0.023096710357665889
7.6574851639899029 -0.56245831840477167 -0.71109293289184572
6.2236787284430282 3.6834630361370069 -0.22991413974761971
6.0242336155279892 2.5117216121868116 -0.27267863216400157
6.2591333085211529 3.6669573188213329 -0.27012791576385509
5.0301510374029883 4.082918324375532 -0.19396550794601444
7.0049008109625595 -0.033774990896798911 -0.31695746286392223
5.9701256779059184 2.5117216121868116 -0.24005698478698737
6.2236787284430282 3.6834630361370069 -0.22991413974761971
5.0012494681891226 4.1083451250652301 -0.24939427579879772
5.0301510374029883 4.082918324375532 -0.19396550794601444
5.0012494681891226 4.1083451250652301 -0.24939427579879772
5.0283079716070906 4.082918324375532 -0.30574542678833017
6.242801669727208 3.7733784974102003 -0.30948805202484136
6.2223727616461533 3.6834630361370069 -0.30915132596969613
5.9088218229254492 3.8402677285198195 -0.31824050470352183
5.9431780204352158 3.9219302051738727 -0.30824059425354011
6.2441076365240837 3.7733784974102003 -0.23025086580276494
2.0079564390143174 -0.40719416425666988 -0.82893751062393184
3.4010098582037709 1.2099572622875197 -0.36178214687347421
5.9593675748785744 3.9493766694072709 -0.26518686319351198
6.2861948350104111 3.7887414937786081 -0.27057394474029545
6.242801669727208 3.7733784974102003 -0.30948805202484136
5.9431780204352158 3.9219302051738727 -0.30824059425354011
5.3236015751227157 4.2116641286663032 -0.31673951831817637
5.325729817310215 4.2391110967449173 -0.25474265573501592
5.9593675748785744 3.9493766694072709 -0.26518686319351198
5.9446049100836529 3.9219302051738727 -0.22162292587280283
6.2441076365240837 3.7733784974102003 -0.23025086580276494
6.2861948350104111 3.7887414937786081 -0.27057394474029545
5.5084261075934178 4.1705579168132765 -0.25775404411315922
5.4939355192145118 4.1453223253826126 -0.19775319583892828
6.2441076365240837 3.7733784974102003 -0.23025086580276494
6.2861948350104111 3.7887414937786081 -0.27057394474029545
5.4110348429449822 4.2148680803874958 -0.25614873027801521
5.3977947983893166 4.1841053069499949 -0.18729166870117195
5.3256461790045506 4.2116641286663032 -0.19270957927703866
5.325729817310215 4.2391110967449173 -0.25474265573501592
5.2464689188727158 4.2171666222576123 -0.30934137008667001
5.2365995988043563 4.2436996151164994 -0.25327353755950938
5.2365995988043563 4.2436996151164994 -0.25327353755950938
5.2483109769781837 4.2171666222576123 -0.19756141975402838
1.9134653074225207 1.1754945015148146 -0.20186835163116462
2.0079564390143174 1.1511572661022169 -0.14016620700836188
2.0079564390143174 1.1865010002330763 -0.25337717222213757
6.2223727616461533 3.6834630361370069 -0.30915132596969613
6.2591333085211529 3.6669573188213329 -0.27012791576385509
6.0242336155279892 2.5117216121868116 -0.27267863216400157
5.9688197111090435 2.5117216121868116 -0.3098861212348939
5.1602972794684181 4.2095076711467723 -0.25201584543228162
5.188093412280919 4.189607800541304 -0.19656890766143809
6.1433265012701757 1.2606799898723586 -0.34498331760406503
6.1687112308844343 1.2606983802227003 -0.31582220512390147
1.0273577665289659 -1.0936030321308152 -0.88317786506652851
1.0075516111334581 -1.0936030321308152 -0.77226169437408454
7.5401335673102166 0.99531831903495604 1.7092159814453125
6.242801669727208 3.7733784974102003 -0.30948805202484136
6.2861948350104111 3.7887414937786081 -0.27057394474029545
0.81775211101138734 1.0075674260143261 -0.21334944105148324
5.2365995988043563 4.2436996151164994 -0.25327353755950938
5.2483109769781837 4.2171666222576123 -0.19756141975402838
5.2483109769781837 4.2171666222576123 -0.19756141975402838
6.9605150706061147 -1.9203591182514206 -0.4474445247268678
7.0947857896002544 -1.9163978871723191 -0.48706853417396556
6.8916908219488873 -1.9203588663288134 -0.48706851842880255
6.8377128763922475 -1.2574440489002245 -0.41843889573097237
6.4851492026861921 -1.2574445527454394 -0.43117098558425909
7.1617851108893174 -1.9163980131336229 -0.43117096983909614
6.4851492026861921 -1.2574445527454394 -0.43117098558425909
6.8377128763922475 -1.2574440489002245 -0.41843889573097237
6.8377128763922475 -1.2574440489002245 -0.48706851842880255
8.1726991422613864 -2.9423967923542036 -0.4474445247268678
8.2836176432379514 -2.890898772945024 -0.41843889573097237
7.4260206876715431 -1.9220619891162889 -0.41843887998580942
8.6267715037115842 -2.8189446378131882 -0.55569809389114388
8.8968375773199817 -2.6953247028156295 -0.52669252787590037
8.8051397635992785 -2.7984852470966355 -0.52669252787590037
8.6267715037115842 -2.8189446378131882 -0.41843887998580942
8.7108894700201756 -2.8725580513568891 -0.4474445247268678
8.8051397635992785 -2.7984852470966355 -0.4474445247268678
8.3701651511725199 -2.9386927742572797 -0.41843889573097237
8.5000614860113881 -2.9713958556171436 -0.4474445247268678
7.1617851108893174 -1.9163980131336229 -0.43117096983909614
8.3701651511725199 -2.9386927742572797 -0.55569809389114388
8.5000614860113881 -2.9713958556171436 -0.52669251213073742
8.3744569047125594 -3.0015169821735399 -0.52669251213073742
8.2636532804449807 -2.9881446782489793 -0.4474445247268678
8.3744569047125594 -3.0015169821735399 -0.4474445247268678
8.5821298099859966 -1.2568793643756884 -0.52669251213073742
7.7779485087164666 -1.2568793643756884 -0.55569809389114388
7.7779485087164666 -1.2568793643756884 -0.48706853417396556
8.1394776041754504 -2.9557693482013718 -0.48706851842880255
8.1726991422613864 -2.9423967923542036 -0.4474445247268678
6.9605150706061147 -1.9203591182514206 -0.4474445247268678
8.7108894700201756 -2.8725580513568891 -0.52669251213073742
8.1726991422613864 -2.9423967923542036 -0.52669252787590037
6.9605150706061147 -1.9203591182514206 -0.52669251213073742
7.1617851108893174 -1.9163980131336229 -0.54296603552818312
6.4851492026861921 -1.2574445527454394 -0.43117098558425909
6.3922552604254506 -1.2574440489002245 -0.48706853417396556
7.0947857896002544 -1.9163978871723191 -0.48706853417396556
7.1617851108893174 -1.9163980131336229 -0.43117096983909614
8.1726991422613864 -2.9423967923542036 -0.4474445247268678
6.4851492026861921 -1.2574445527454394 -0.54296600403785711
6.8377128763922475 -1.2574440489002245 -0.55569810963630684
8.1394776041754504 -2.9557693482013718 -0.48706851842880255
6.8916908219488873 -1.9203588663288134 -0.48706851842880255
6.9605150706061147 -1.9203591182514206 -0.52669251213073742
8.2836176432379514 -2.890898772945024 -0.55569807814598093
8.2636532804449807 -2.9881446782489793 -0.52669252787590037
8.5099600291022082 -2.9904774815937056 -0.48704732543945323
8.363569817310216 -3.0220000536151903 -0.48706853417396556
8.3744569047125594 -3.0015169821735399 -0.52669251213073742
8.5000614860113881 -2.9713958556171436 -0.52669251213073742
8.363569817310216 -3.0220000536151903 -0.48706853417396556
8.3744569047125594 -3.0015169821735399 -0.4474445247268678
8.2636532804449807 -2.9881446782489793 -0.4474445247268678
8.2317538322027932 -3.0009854254718795 -0.48706851842880255
6.8377128763922475 -1.2574440489002245 -0.55569810963630684
6.8916908219488873 -1.9203588663288134 -0.48706851842880255
6.3922552604254506 -1.2574440489002245 -0.48706853417396556
7.4260206876715431 -1.9220619891162889 -0.55569810963630684
6.4851492026861921 -1.2574445527454394 -0.54296600403785711
7.1617851108893174 -1.9163980131336229 -0.54296603552818312
7.0947857896002544 -1.9163978871723191 -0.48706853417396556
6.3922552604254506 -1.2574440489002245 -0.48706853417396556
8.8968375773199817 -2.6953247028156295 -0.4474445247268678
8.2317538322027932 -3.0009854254718795 -0.48706851842880255
8.1726991422613864 -2.9423967923542036 -0.52669252787590037
8.2636532804449807 -2.9881446782489793 -0.52669252787590037
8.5886435209234957 -2.7482889118000045 -0.41843887998580942
6.9605150706061147 -1.9203591182514206 -0.52669251213073742
7.1617851108893174 -1.9163980131336229 -0.54296603552818312
8.5886435209234957 -2.7482889118000045 -0.55569809389114388
8.8778456357916617 -2.6175632477375044 -0.52669252787590037
8.5821298099859966 -1.2568793643756884 -0.52669251213073742
7.7779485087164666 -1.2568793643756884 -0.55569809389114388
8.5099600291022082 -2.9904774815937056 -0.48704732543945323
8.7207880131109974 -2.8916396773334521 -0.48704732543945323
8.7108894700201756 -2.8725580513568891 -0.4474445247268678
8.5000614860113881 -2.9713958556171436 -0.4474445247268678
8.5821298099859966 -1.2568793643756884 -0.4474445247268678
7.7779485087164666 -1.2568793643756884 -0.41843887998580942
8.8778456357916617 -2.6175632477375044 -0.4474445247268678
6.4851492026861921 -1.2574445527454394 -0.54296600403785711
8.8051397635992785 -2.7984852470966355 -0.4474445247268678
8.8339264561041606 -2.8067342009540575 -0.48706854991912851
8.5821298099859966 -1.2568793643756884 -0.4474445247268678
8.6278658555182233 -1.2568793643756884 -0.48706853417396556
8.6278658555182233 -1.2568793643756884 -0.48706853417396556
8.9197605192145133 -2.6022796069904341 -0.48706851842880255
8.8778456357916617 -2.6175632477375044 -0.52669252787590037
8.5821298099859966 -1.2568793643756884 -0.52669251213073742
6.9605150706061147 -1.9203591182514206 -0.4474445247268678
8.8968375773199817 -2.6953247028156295 -0.4474445247268678
8.9370867484625602 -2.6997524945636764 -0.48706851842880255
8.9197605192145133 -2.6022796069904341 -0.48706851842880255
8.8778456357916617 -2.6175632477375044 -0.4474445247268678
8.6278658555182233 -1.2568793643756884 -0.48706853417396556
8.5821298099859966 -1.2568793643756884 -0.4474445247268678
8.7108894700201756 -2.8725580513568891 -0.52669251213073742
8.7207880131109974 -2.8916396773334521 -0.48704732543945323
8.8968375773199817 -2.6953247028156295 -0.52669252787590037
8.9370867484625602 -2.6997524945636764 -0.48706851842880255
7.7779485087164666 -1.2568793643756884 -0.41843887998580942
8.8339264561041606 -2.8067342009540575 -0.48706854991912851
8.8051397635992785 -2.7984852470966355 -0.52669252787590037
8.8968375773199817 -2.6953247028156295 -0.52669252787590037
8.9370867484625602 -2.6997524945636764 -0.48706851842880255
8.9370867484625602 -2.6997524945636764 -0.48706851842880255
8.8968375773199817 -2.6953247028156295 -0.4474445247268678
8.5821308176764273 1.0111680298809034 -0.44744455621719365
7.7779495164068946 1.0111680298809034 -0.48706856566429152
8.6278668632086539 1.0111680298809034 -0.48706854991912851
8.2836186509283785 2.645187186527632 -0.41843891147613527
8.263655295825842 2.7424330918315873 -0.44744455621719365
8.172700149951817 2.6966852059368116 -0.44744455621719365
8.1394786118658793 2.7100582656291943 -0.48706856566429152
6.9605160782965436 1.674647783756636 -0.52669255936622628
6.891691829639317 1.674647783756636 -0.48706854991912851
6.9605160782965436 1.674647783756636 -0.52669255936622628
7.0947867972906851 1.6706864267162309 -0.48706856566429152
6.891691829639317 1.674647783756636 -0.48706854991912851
6.485150210376621 1.0117332182506544 -0.54296605127334596
6.8377128763922475 1.0117327144054395 -0.48706854991912851
6.3922552604254506 1.0117327144054395 -0.48706856566429152
7.4260206876715431 1.6763509065441118 -0.55569814112663274
8.172700149951817 2.6966852059368116 -0.52669255936622628
8.2836186509283785 2.645187186527632 -0.55569812538146979
7.1617861185797471 1.670686804600142 -0.54296605127334596
6.9605160782965436 1.674647783756636 -0.52669255936622628
6.8377128763922475 1.0117327144054395 -0.55569814112663274
6.485150210376621 1.0117332182506544 -0.54296605127334596
6.9605160782965436 1.674647783756636 -0.44744455621719365
7.1617861185797471 1.670686804600142 -0.43117100132942204
7.4260206876715431 1.6763509065441118 -0.41843891147613527
6.8377128763922475 1.0117327144054395 -0.41843892722129827
6.485150210376621 1.0117332182506544 -0.43117101707458505
6.485150210376621 1.0117332182506544 -0.43117101707458505
6.8377128763922475 1.0117327144054395 -0.41843892722129827
6.9605160782965436 1.674647783756636 -0.44744455621719365
7.0947867972906851 1.6706864267162309 -0.48706856566429152
7.1617861185797471 1.670686804600142 -0.43117100132942204
8.1394786118658793 2.7100582656291943 -0.48706856566429152
6.9605160782965436 1.674647783756636 -0.44744455621719365
8.172700149951817 2.6966852059368116 -0.44744455621719365
8.3701661588629488 2.6929816916851026 -0.41843891147613527
8.374458920093419 2.7558058996013628 -0.44744455621719365
8.5821308176764273 1.0111680298809034 -0.52669255936622628
7.7779495164068946 1.0111680298809034 -0.55569812538146979
8.6267725114020113 2.5732330513957962 -0.41843891147613527
8.8051397635992785 2.5527741645244579 -0.44744455621719365
8.7108904777106062 2.6268464649394971 -0.44744455621719365
8.5000635013922476 2.7256842691997512 -0.44744455621719365
8.6267725114020113 2.5732330513957962 -0.55569812538146979
8.8051397635992785 2.5527741645244579 -0.52669255936622628
8.8968395927008412 2.4496131163982375 -0.52669255936622628
8.3701661588629488 2.6929816916851026 -0.55569814112663274
8.374458920093419 2.7558058996013628 -0.52669255936622628
8.5000635013922476 2.7256842691997512 -0.52669255936622628
8.7108904777106062 2.6268464649394971 -0.52669254362106332
8.509961036792637 2.7447663990215285 -0.48704734118461612
8.7207890208014263 2.645928594761275 -0.48704734118461612
8.7108904777106062 2.6268464649394971 -0.52669254362106332
8.5000635013922476 2.7256842691997512 -0.52669255936622628
8.588645536304357 2.5025773253826125 -0.41843891147613527
7.7779495164068946 1.0111680298809034 -0.41843891147613527
8.8339274637945913 2.5610231183818803 -0.48706856566429152
8.937088763843418 2.4540414119914993 -0.48706854991912851
8.8968395927008412 2.4496131163982375 -0.52669255936622628
8.8051397635992785 2.5527741645244579 -0.52669255936622628
8.263655295825842 2.7424330918315873 -0.52669255936622628
8.5821308176764273 1.0111680298809034 -0.52669255936622628
7.7779495164068946 1.0111680298809034 -0.55569812538146979
8.588645536304357 2.5025773253826125 -0.55569812538146979
8.8778466434820906 2.3718516613201124 -0.52669255936622628
8.3635718326910755 2.7762889710430128 -0.48706856566429152
8.2317548398932221 2.7552743428997024 -0.48706854991912851
8.263655295825842 2.7424330918315873 -0.44744455621719365
8.374458920093419 2.7558058996013628 -0.44744455621719365
6.8377128763922475 1.0117327144054395 -0.55569814112663274
8.6278668632086539 1.0111680298809034 -0.48706854991912851
8.5821308176764273 1.0111680298809034 -0.52669255936622628
8.8778466434820906 2.3718516613201124 -0.52669255936622628
8.9197625345953728 2.356568524418257 -0.48706854991912851
7.7779495164068946 1.0111680298809034 -0.41843891147613527
8.5821308176764273 1.0111680298809034 -0.44744455621719365
8.8778466434820906 2.3718516613201124 -0.44744455621719365
8.172700149951817 2.6966852059368116 -0.52669255936622628
7.1617861185797471 1.670686804600142 -0.54296605127334596
6.485150210376621 1.0117332182506544 -0.54296605127334596
6.3922552604254506 1.0117327144054395 -0.48706856566429152
7.0947867972906851 1.6706864267162309 -0.48706856566429152
7.1617861185797471 1.670686804600142 -0.54296605127334596
6.891691829639317 1.674647783756636 -0.48706854991912851
8.2317548398932221 2.7552743428997024 -0.48706854991912851
8.263655295825842 2.7424330918315873 -0.52669255936622628
8.8968395927008412 2.4496131163982375 -0.52669255936622628
8.937088763843418 2.4540414119914993 -0.48706854991912851
8.8968395927008412 2.4496131163982375 -0.44744455621719365
8.3635718326910755 2.7762889710430128 -0.48706856566429152
8.374458920093419 2.7558058996013628 -0.52669255936622628
8.8339274637945913 2.5610231183818803 -0.48706856566429152
8.8051397635992785 2.5527741645244579 -0.44744455621719365
8.8968395927008412 2.4496131163982375 -0.44744455621719365
8.937088763843418 2.4540414119914993 -0.48706854991912851
8.6278668632086539 1.0111680298809034 -0.48706854991912851
8.9197625345953728 2.356568524418257 -0.48706854991912851
8.8778466434820906 2.3718516613201124 -0.44744455621719365
8.5821308176764273 1.0111680298809034 -0.44744455621719365
8.8968395927008412 2.4496131163982375 -0.44744455621719365
8.937088763843418 2.4540414119914993 -0.48706854991912851
8.509961036792637 2.7447663990215285 -0.48704734118461612
8.5000635013922476 2.7256842691997512 -0.44744455621719365
8.7108904777106062 2.6268464649394971 -0.44744455621719365
8.7207890208014263 2.645928594761275 -0.48704734118461612
6.485150210376621 1.0117332182506544 -0.43117101707458505
7.1617861185797471 1.670686804600142 -0.43117100132942204
7.0947867972906851 1.6706864267162309 -0.48706856566429152
6.3922552604254506 1.0117327144054395 -0.48706856566429152
7.3082619840582623 -1.2285044393726365 1.7751184317016599
8.0436603519781844 -1.2285044393726365 1.7751184317016599
8.0436603519781844 -1.2379553159900683 1.7398472512817384
7.3082619840582623 -1.2379553159900683 1.7398472512817384
7.3082619840582623 -1.2379553159900683 1.7398472512817384
8.0436603519781844 -1.2379553159900683 1.7398472512817384
8.0436603519781844 -1.2637756197925585 1.7140269474792478
7.3082619840582623 -1.2637756197925585 1.7140266955566408
7.3082619840582623 -1.2637756197925585 1.7140266955566408
8.0436603519781844 -1.2637756197925585 1.7140269474792478
8.0436603519781844 -1.299046926173784 1.7045760708618161
7.3082619840582623 -1.299046926173784 1.7045760708618161
7.3082619840582623 -1.299046926173784 1.7045760708618161
8.0436603519781844 -1.299046926173784 1.7045760708618161
8.0436603519781844 -1.334318106593706 1.7140269474792478
7.3082619840582623 -1.334318106593706 1.7140266955566408
7.3082619840582623 -1.334318106593706 1.7140266955566408
8.0436603519781844 -1.334318106593706 1.7140269474792478
8.0436603519781844 -1.3601384103961962 1.7398472512817384
7.3082619840582623 -1.3601384103961962 1.7398472512817384
7.3082619840582623 -1.3601384103961962 1.7398472512817384
8.0436603519781844 -1.3601384103961962 1.7398472512817384
8.0436603519781844 -1.3695892870136277 1.7751184317016599
7.3082619840582623 -1.3695892870136277 1.7751184317016599
7.3082619840582623 -1.3695892870136277 1.7751184317016599
8.0436603519781844 -1.3695892870136277 1.7751184317016599
8.0436603519781844 -1.3601384103961962 1.8103898640441891
7.3082619840582623 -1.3601384103961962 1.8103896121215823
7.3082619840582623 -1.3601384103961962 1.8103896121215823
8.0436603519781844 -1.3601384103961962 1.8103898640441891
8.0436603519781844 -1.334318106593706 1.8362099159240721
7.3082619840582623 -1.334318106593706 1.8362096640014647
7.3082619840582623 -1.334318106593706 1.8362096640014647
8.0436603519781844 -1.334318106593706 1.8362099159240721
8.0436603519781844 -1.299046926173784 1.8456607925415038
7.3082619840582623 -1.299046926173784 1.8456607925415038
7.3082619840582623 -1.299046926173784 1.8456607925415038
8.0436603519781844 -1.299046926173784 1.8456607925415038
8.0436603519781844 -1.2637756197925585 1.8362099159240721
7.3082619840582623 -1.2637756197925585 1.8362099159240721
8.0436603519781844 -1.334318106593706 1.8362099159240721
8.0436603519781844 -1.3601384103961962 1.8103898640441891
8.0795905619391224 -1.3465934135242481 1.8025696824645996
8.0795905619391224 -1.3264977990528124 1.8226650450134274
7.3082619840582623 -1.2637756197925585 1.8362099159240721
8.0436603519781844 -1.2637756197925585 1.8362099159240721
8.0436603519781844 -1.2379553159900683 1.8103898640441891
7.3082619840582623 -1.2379554419513721 1.8103896121215823
7.3082619840582623 -1.2379554419513721 1.8103896121215823
8.0436603519781844 -1.2379553159900683 1.8103898640441891
8.0436603519781844 -1.2285044393726365 1.7751184317016599
7.3082619840582623 -1.2285044393726365 1.7751184317016599
7.2363995487555277 -1.3546427187152879 1.7430202165222168
7.2363995487555277 -1.3311451413532276 1.7195226391601559
8.0795905619391224 -1.3465934135242481 1.7476674328613278
8.0795905619391224 -1.3264977990528124 1.7275720703124999
8.0989382181891223 -1.3134455628009813 1.7501791012573238
8.0989382181891223 -1.3239861306568164 1.7607195431518552
8.0436603519781844 -1.3601384103961962 1.8103898640441891
8.0436603519781844 -1.3695892870136277 1.7751184317016599
8.0795905619391224 -1.3539489238544482 1.7751184317016599
8.0795905619391224 -1.3465934135242481 1.8025696824645996
8.0436603519781844 -1.3695892870136277 1.7751184317016599
8.0436603519781844 -1.3601384103961962 1.7398472512817384
8.0795905619391224 -1.3465934135242481 1.7476674328613278
8.0795905619391224 -1.3539489238544482 1.7751184317016599
8.0436603519781844 -1.3601384103961962 1.7398472512817384
8.0436603519781844 -1.334318106593706 1.7140269474792478
8.0795905619391224 -1.3264977990528124 1.7275720703124999
8.0795905619391224 -1.3465934135242481 1.7476674328613278
8.0436603519781844 -1.334318106593706 1.7140269474792478
8.0436603519781844 -1.299046926173784 1.7045760708618161
8.0795905619391224 -1.299046926173784 1.7202164340209962
8.0795905619391224 -1.3264977990528124 1.7275720703124999
8.0436603519781844 -1.2285044393726365 1.7751184317016599
8.0436603519781844 -1.2379553159900683 1.8103898640441891
8.0795905619391224 -1.251500186900713 1.8025696824645996
8.0795905619391224 -1.2441448025318163 1.7751184317016599
8.0436603519781844 -1.2379553159900683 1.7398472512817384
8.0436603519781844 -1.2285044393726365 1.7751184317016599
8.0795905619391224 -1.2441448025318163 1.7751184317016599
8.0795905619391224 -1.251500186900713 1.7476674328613278
8.0436603519781844 -1.299046926173784 1.7045760708618161
8.0436603519781844 -1.2637756197925585 1.7140269474792478
8.0795905619391224 -1.2715958013721482 1.7275720703124999
8.0795905619391224 -1.299046926173784 1.7202164340209962
8.0436603519781844 -1.2379553159900683 1.8103898640441891
8.0436603519781844 -1.2637756197925585 1.8362099159240721
8.0795905619391224 -1.2715958013721482 1.8226650450134274
8.0795905619391224 -1.251500186900713 1.8025696824645996
8.0436603519781844 -1.2637756197925585 1.7140269474792478
8.0436603519781844 -1.2379553159900683 1.7398472512817384
8.0795905619391224 -1.251500186900713 1.7476674328613278
8.0795905619391224 -1.2715958013721482 1.7275720703124999
8.0436603519781844 -1.2637756197925585 1.8362099159240721
8.0436603519781844 -1.299046926173784 1.8456607925415038
8.0795905619391224 -1.299046926173784 1.8300206813049318
8.0795905619391224 -1.2715958013721482 1.8226650450134274
8.0436603519781844 -1.299046926173784 1.8456607925415038
8.0436603519781844 -1.334318106593706 1.8362099159240721
8.0795905619391224 -1.3264977990528124 1.8226650450134274
8.0795905619391224 -1.299046926173784 1.8300206813049318
8.0989382181891223 -1.2846481635852831 1.7501791012573238
8.0989382181891223 -1.2741075957294481 1.7607195431518552
8.0989382181891223 -1.2702494009967822 1.7751184317016599
8.0989382181891223 -1.2741075957294481 1.7895170683288573
8.0989382181891223 -1.2846481635852831 1.8000577621459961
8.0989382181891223 -1.299046926173784 1.803915956878662
8.0989382181891223 -1.3134455628009813 1.8000577621459961
8.0989382181891223 -1.3239861306568164 1.7895170683288573
8.0989382181891223 -1.3278443253894823 1.7751184317016599
8.0989382181891223 -1.3239861306568164 1.7607195431518552
8.0989382181891223 -1.3134455628009813 1.7501791012573238
8.0989382181891223 -1.299046926173784 1.7463209065246579
8.0989382181891223 -1.2846481635852831 1.7501791012573238
8.0795905619391224 -1.2441448025318163 1.7751184317016599
8.0795905619391224 -1.251500186900713 1.8025696824645996
8.0989382181891223 -1.2741075957294481 1.7895170683288573
8.0989382181891223 -1.2702494009967822 1.7751184317016599
8.0795905619391224 -1.2715958013721482 1.7275720703124999
8.0795905619391224 -1.251500186900713 1.7476674328613278
8.0989382181891223 -1.2741075957294481 1.7607195431518552
8.0989382181891223 -1.2846481635852831 1.7501791012573238
8.0795905619391224 -1.299046926173784 1.8300206813049318
8.0795905619391224 -1.3264977990528124 1.8226650450134274
8.0989382181891223 -1.3134455628009813 1.8000577621459961
8.0989382181891223 -1.299046926173784 1.803915956878662
8.0795905619391224 -1.3539489238544482 1.7751184317016599
8.0989382181891223 -1.3278443253894823 1.7751184317016599
8.0795905619391224 -1.299046926173784 1.7202164340209962
8.0989382181891223 -1.299046926173784 1.7463209065246579
8.0795905619391224 -1.2715958013721482 1.8226650450134274
8.0989382181891223 -1.2846481635852831 1.8000577621459961
8.0795905619391224 -1.3465934135242481 1.8025696824645996
8.0989382181891223 -1.3239861306568164 1.7895170683288573
7.2363995487555277 -1.3546427187152879 1.8072166468811037
7.2363995487555277 -1.3311451413532276 1.830714224243164
7.1673022159918558 -1.3253790107532519 1.8207267524719237
7.1673022159918558 -1.3446553729053514 1.8014503903198238
7.2363995487555277 -1.3311451413532276 1.7195226391601559
7.2363995487555277 -1.299046926173784 1.7109220013427731
7.2363995487555277 -1.2348504958148974 1.7751184317016599
7.2363995487555277 -1.2434511336322802 1.8072166468811037
7.2363995487555277 -1.2434511336322802 1.7430202165222168
7.2363995487555277 -1.2348504958148974 1.7751184317016599
7.2363995487555277 -1.299046926173784 1.7109220013427731
7.2363995487555277 -1.2669485850330371 1.7195226391601559
7.2363995487555277 -1.2434511336322802 1.8072166468811037
7.2363995487555277 -1.2669487109943407 1.830714224243164
7.2363995487555277 -1.2669485850330371 1.7195226391601559
7.2363995487555277 -1.2434511336322802 1.7430202165222168
7.2363995487555277 -1.2669487109943407 1.830714224243164
7.2363995487555277 -1.299046926173784 1.8393146101379392
7.2363995487555277 -1.299046926173784 1.8393146101379392
7.2363995487555277 -1.3311451413532276 1.830714224243164
7.2363995487555277 -1.3546427187152879 1.8072166468811037
7.2363995487555277 -1.3632433565326707 1.7751184317016599
7.2363995487555277 -1.3632433565326707 1.7751184317016599
7.2363995487555277 -1.3546427187152879 1.7430202165222168
7.1673022159918558 -1.2463827570148485 1.7751184317016599
7.1673022159918558 -1.253438353480913 1.7487864730834961
7.1046541019781841 -1.2713665517993944 1.7591369653320312
7.1046541019781841 -1.2670843713184374 1.7751184317016599
7.1673022159918558 -1.3446553729053514 1.7487864730834961
7.1673022159918558 -1.3253790107532519 1.7295098590087892
7.1673022159918558 -1.2463827570148485 1.7751184317016599
7.1673022159918558 -1.253438353480913 1.8014506422424315
7.1673022159918558 -1.2727148415943164 1.7295098590087892
7.1673022159918558 -1.253438353480913 1.7487864730834961
7.1673022159918558 -1.299046926173784 1.8277823489379885
7.1673022159918558 -1.3253790107532519 1.8207267524719237
7.1673022159918558 -1.3517109693714158 1.7751184317016599
7.1673022159918558 -1.3446553729053514 1.7487864730834961
7.1673022159918558 -1.299046926173784 1.7224540106201169
7.1673022159918558 -1.2727148415943164 1.7295098590087892
7.1673022159918558 -1.2727148415943164 1.8207267524719237
7.1673022159918558 -1.299046926173784 1.8277823489379885
7.1673022159918558 -1.3446553729053514 1.8014503903198238
7.1673022159918558 -1.3517109693714158 1.7751184317016599
7.1673022159918558 -1.3253790107532519 1.7295098590087892
7.1673022159918558 -1.299046926173784 1.7224540106201169
7.1673022159918558 -1.253438353480913 1.8014506422424315
7.1673022159918558 -1.2727148415943164 1.8207267524719237
7.1046541019781841 -1.2830657117267625 1.802798680114746
7.1046541019781841 -1.2713665517993944 1.7910996461486817
7.0659608048590439 -1.2871136041828173 1.7820080111694339
7.0659608048590439 -1.2921573467060108 1.7870517536926267
7.1046541019781841 -1.3150281406208058 1.802798680114746
7.1046541019781841 -1.3267273005481737 1.7910996461486817
7.1046541019781841 -1.3267273005481737 1.7591369653320312
7.1046541019781841 -1.3150281406208058 1.7474381832885739
7.1046541019781841 -1.2670843713184374 1.7751184317016599
7.1046541019781841 -1.2670843713184374 1.7751184317016599
7.1046541019781841 -1.2713665517993944 1.7910996461486817
7.1046541019781841 -1.2830657117267625 1.7474381832885739
7.1046541019781841 -1.2713665517993944 1.7591369653320312
7.1046541019781841 -1.299046926173784 1.8070808605957027
7.1046541019781841 -1.3150281406208058 1.802798680114746
7.1046541019781841 -1.331009355067827 1.7751184317016599
7.1046541019781841 -1.3267273005481737 1.7591369653320312
7.1046541019781841 -1.299046926173784 1.7431560028076172
7.1046541019781841 -1.2830657117267625 1.7474381832885739
7.1046541019781841 -1.2830657117267625 1.802798680114746
7.1046541019781841 -1.299046926173784 1.8070808605957027
7.1046541019781841 -1.3267273005481737 1.7910996461486817
7.1046541019781841 -1.331009355067827 1.7751184317016599
7.1046541019781841 -1.3150281406208058 1.7474381832885739
7.1046541019781841 -1.299046926173784 1.7431560028076172
7.0659608048590439 -1.2871136041828173 1.7820080111694339
7.0659608048590439 -1.2852675153156299 1.7751184317016599
7.0659608048590439 -1.2871136041828173 1.7682286003112793
7.0659608048590439 -1.2921573467060108 1.7631848577880858
7.0659608048590439 -1.2990470521350879 1.761339020843506
7.0659608048590439 -1.3059367575641649 1.7631848577880858
7.0659608048590439 -1.3109805000873582 1.7682286003112793
7.0659608048590439 -1.3128265889545458 1.7751184317016599
7.0659608048590439 -1.3109805000873582 1.7820080111694339
7.0659608048590439 -1.3059367575641649 1.7870517536926267
7.0659608048590439 -1.2990470521350879 1.7888978425598145
7.0659608048590439 -1.2921573467060108 1.7870517536926267
7.0659608048590439 -1.2871136041828173 1.7682286003112793
7.0659608048590439 -1.2852675153156299 1.7751184317016599
7.0659608048590439 -1.3059367575641649 1.7870517536926267
7.0659608048590439 -1.3109805000873582 1.7820080111694339
7.0659608048590439 -1.3109805000873582 1.7682286003112793
7.0659608048590439 -1.3059367575641649 1.7631848577880858
7.0659608048590439 -1.2852675153156299 1.7751184317016599
7.0659608048590439 -1.2871136041828173 1.7820080111694339
7.0659608048590439 -1.2921573467060108 1.7631848577880858
7.0659608048590439 -1.2871136041828173 1.7682286003112793
7.0659608048590439 -1.2990470521350879 1.7888978425598145
7.0659608048590439 -1.3059367575641649 1.7870517536926267
7.0659608048590439 -1.3128265889545458 1.7751184317016599
7.0659608048590439 -1.3109805000873582 1.7682286003112793
7.0659608048590439 -1.2990470521350879 1.761339020843506
7.0659608048590439 -1.2921573467060108 1.7631848577880858
7.0659608048590439 -1.2921573467060108 1.7870517536926267
7.0659608048590439 -1.2990470521350879 1.7888978425598145
7.0659608048590439 -1.3109805000873582 1.7820080111694339
7.0659608048590439 -1.3128265889545458 1.7751184317016599
7.0659608048590439 -1.3059367575641649 1.7631848577880858
7.0659608048590439 -1.2990470521350879 1.761339020843506
-0.096752901958583076 0.9449029370311719 -0.14122062908172611
-0.042001553997157437 0.93418778680839354 -0.10889398307800302
0.28055838908755976 1.2633497397045119 0.010463673324584888
0.22580956035220764 1.2740651418498976 -0.021863917388916142
1.5303419099005475 2.5135571203044877 0.46418195755004876
1.4755900580939068 2.5242252869609816 0.4319935540771484
2.0198935398443956 1.2740651418498976 0.013778345031738208
1.9952827164801374 1.2633498656658155 0.044529278106689378
1.4868585563238872 0.92673138147392109 -0.056781776351928819
1.5411705512579692 0.94490306299247562 -0.10868104549407964
0.5855328745611923 0.97410756914176766 -0.21281001176834113
0.9875313215216418 0.96995588457145521 -0.19271984512329113
0.98859896953189541 0.81335411584892092 -0.24643472049713142
0.58660001872623146 0.81750573743858157 -0.26652491863250738
1.2284675840338488 1.3003521322826368 -0.078582025146484463
1.9971439207037707 1.2954953163341505 -0.049152048263549859
1.4895828474005479 0.97378976877250489 -0.19392277557373058
0.50283373637759821 1.2593560106090529 0.026522479934692311
0.28055838908755976 1.2633497397045119 0.010463673324584888
-0.042001553997157437 0.93418778680839354 -0.10889398307800302
0.19663667049014766 0.92937946596183596 -0.090134629096984983
1.9952827164801374 1.2633498656658155 0.044529278106689378
1.2260440885504504 1.2584929237560254 0.043406459045410066
0.98525091807925869 0.93056513971366706 -0.077924066276550394
1.4868585563238872 0.92673138147392109 -0.056781776351928819
0.86790184062564557 1.2563513296703321 0.042535562591552625
0.58277129893863344 0.92641339216270269 -0.073816027297973763
0.28241959331119232 1.2954953163341505 -0.083217590065002553
0.50515747050845816 1.2994890454296093 -0.090436243438720795
0.19905462367618254 0.97114181024589363 -0.21184045612335214
-0.040140349773524195 0.96633323747672861 -0.20257423877716071
0.87057322795474701 1.3024937263683303 -0.091936316604614363
-0.096752901958583076 0.9449029370311719 -0.14122062908172611
-0.096132416576503288 0.95561808725395037 -0.17244741247177131
-0.095065524334071644 0.79901612958946044 -0.22616279169082645
-0.095685757793543866 0.788301042347334 -0.19493553594589244
0.20012151591861418 0.81453978960075202 -0.26555637067794813
-0.096132416576503288 0.95561808725395037 -0.17244741247177131
-0.040140349773524195 0.96633323747672861 -0.20257423877716071
-0.039073205608485706 0.80973140577354252 -0.25628964948654182
-0.095065524334071644 0.79901612958946044 -0.22616279169082645
1.9268554978522077 2.5487300509075146 0.36951819599151597
2.1805405558356061 2.5469383773235306 0.37978070426940913
2.0205142771490827 1.2847801661113722 -0.017448469848632919
1.9971439207037707 1.2954953163341505 -0.049152048263549859
2.4970833274420521 2.5455606125835404 0.39008610237121571
2.5204562031134383 2.534892949772261 0.42165036758422836
1.9246400904425398 2.5104657779888138 0.48103003768920899
1.6809800406988873 2.511745544834517 0.47245774116516109
2.3197368656500594 2.8282646357158643 0.58785366264343253
2.1785327326544541 2.512257199650191 0.48085092071533186
2.4952306885870708 2.5135571203044877 0.48335125259399397
2.5118036692389274 2.5859551430706009 0.50852411529541008
2.5140603919562121 2.6620576877788529 0.53468123962402336
2.4927890546759386 2.733389070225142 0.55873606979370105
2.4447045865973251 2.7861426719097122 0.57588293014526359
2.3845872870978138 2.816356002140425 0.58505555824279765
1.5303419099005475 2.5135571203044877 0.46418195755004876
1.9499618394049421 2.8282646357158643 0.58050772537231432
1.8379268174322858 2.8282646357158643 0.57828198913574202
2.1311143479498638 2.8282646357158643 0.58410694366455074
1.8379268174322858 2.8282646357158643 0.57828198913574202
1.799102016712071 2.8615090987590772 0.55415737640380847
1.6830473176153913 2.5474500321392042 0.36840532787322988
1.532194548755528 2.5455606125835404 0.3709177520370483
2.4970833274420521 2.5455606125835404 0.39008610237121571
1.799102016712071 2.8615090987590772 0.55415737640380847
1.8379268174322858 2.8282646357158643 0.57828198913574202
1.9499618394049421 2.8282646357158643 0.58050772537231432
1.9665091239508403 2.8615090987590772 0.5574819990539549
2.1311143479498638 2.8282646357158643 0.58410694366455074
2.1476616324957623 2.8615090987590772 0.56108121734619132
2.3197368656500594 2.8282646357158643 0.58785366264343253
2.3362841501959579 2.8615090987590772 0.56482806228637683
2.1329674906500595 2.860267624149702 0.49084065979003894
2.3215900083502552 2.860267624149702 0.49458851242065427
1.8397794562872662 2.860267624149702 0.48501671295166016
1.9518144782599225 2.860267624149702 0.4872424491882324
2.3369018644293567 2.8721770134929643 0.53374056060790998
2.4017507743414659 2.8602686318401322 0.53094245620727532
2.3864404297980086 2.84835924249687 0.49179040802001939
2.3215900083502552 2.860267624149702 0.49458851242065427
2.4618700892218368 2.8300550496868118 0.52176894638061511
2.4465577292975209 2.81814566034355 0.48261664627075185
2.5099540534552358 2.7773014480022415 0.50462309371948233
2.4946421973761339 2.7653920586589797 0.46546991188049308
2.5392879218634388 2.6833935172466261 0.47298224403381339
2.5159130308111917 2.6940609281352983 0.44141697113037098
2.5370296876105085 2.6072907206157665 0.44682297836303708
2.5136568119391218 2.6179583834270459 0.41525783142089828
2.5136568119391218 2.6179583834270459 0.41525783142089828
2.3864404297980086 2.84835924249687 0.49179040802001939
2.4465577292975209 2.81814566034355 0.48261664627075185
2.4946421973761339 2.7653920586589797 0.46546991188049308
2.5159130308111917 2.6940609281352983 0.44141697113037098
2.5118036692389274 2.5859551430706009 0.50852411529541008
2.4952306885870708 2.5135571203044877 0.48335125259399397
2.5198384888800396 2.5242252869609816 0.45273875099182126
2.5364119733771098 2.5966233097270948 0.47791148773193354
2.5364119733771098 2.5966233097270948 0.47791148773193354
2.5198384888800396 2.5242252869609816 0.45273875099182126
2.5204562031134383 2.534892949772261 0.42165036758422836
2.5370296876105085 2.6072907206157665 0.44682297836303708
2.5140603919562121 2.6620576877788529 0.53468123962402336
2.53867020763004 2.6727253505901318 0.50406961975097653
2.53867020763004 2.6727253505901318 0.50406961975097653
2.5392879218634388 2.6833935172466261 0.47298224403381339
2.4927890546759386 2.733389070225142 0.55873606979370105
2.5093363392218371 2.7666337851909621 0.53571046943664546
2.5093363392218371 2.7666337851909621 0.53571046943664546
2.5099540534552358 2.7773014480022415 0.50462309371948233
2.4447045865973251 2.7861426719097122 0.57588293014526359
2.4612523749884385 2.8193873868755324 0.55285720382690429
2.4612523749884385 2.8193873868755324 0.55285720382690429
2.5093363392218371 2.7666337851909621 0.53571046943664546
2.5099540534552358 2.7773014480022415 0.50462309371948233
2.4618700892218368 2.8300550496868118 0.52176894638061511
2.3845872870978138 2.816356002140425 0.58505555824279765
2.4011330601080672 2.8496014728740677 0.56203096557617183
2.3845872870978138 2.816356002140425 0.58505555824279765
2.4011330601080672 2.8496014728740677 0.56203096557617183
2.4017507743414659 2.8602686318401322 0.53094245620727532
2.3362841501959579 2.8615090987590772 0.56482806228637683
2.3369018644293567 2.8721770134929643 0.53374056060790998
2.1329674906500595 2.860267624149702 0.49084065979003894
2.148279346729161 2.8721770134929643 0.52999295989990225
2.148279346729161 2.8721770134929643 0.52999295989990225
2.1476616324957623 2.8615090987590772 0.56108121734619132
1.9518144782599225 2.860267624149702 0.4872424491882324
1.967126334339024 2.8721770134929643 0.52639449737548816
1.967126334339024 2.8721770134929643 0.52639449737548816
1.9665091239508403 2.8615090987590772 0.5574819990539549
1.8397794562872662 2.860267624149702 0.48501671295166016
1.7997197309454698 2.8721770134929643 0.52306886703491207
1.7997197309454698 2.8721770134929643 0.52306886703491207
1.799102016712071 2.8615090987590772 0.55415737640380847
1.532194548755528 2.5455606125835404 0.3709177520370483
1.4762072684820904 2.534892949772261 0.40090529663085928
1.7997197309454698 2.8721770134929643 0.52306886703491207
1.8397794562872662 2.860267624149702 0.48501671295166016
1.4762072684820904 2.534892949772261 0.40090529663085928
1.4755900580939068 2.5242252869609816 0.4319935540771484
1.799102016712071 2.8615090987590772 0.55415737640380847
1.7997197309454698 2.8721770134929643 0.52306886703491207
1.9952827164801374 1.2633498656658155 0.044529278106689378
2.0198935398443956 1.2740651418498976 0.013778345031738208
2.0198935398443956 1.2740651418498976 0.013778345031738208
2.0205142771490827 1.2847801661113722 -0.017448469848632919
2.5204562031134383 2.534892949772261 0.42165036758422836
-0.040934409832118233 0.77758582914390384 -0.16260885845184331
0.19770381465518616 0.77277738233604265 -0.14384950447082528
-0.039073205608485706 0.80973140577354252 -0.25628964948654182
1.5417907847174424 0.95561821321525398 -0.13990729354858411
1.5411705512579692 0.94490306299247562 -0.10868104549407964
1.5422376954230086 0.788301042347334 -0.16239592086792001
1.5428579288824815 0.79901612958946044 -0.19362267276763925
1.4905240302618756 0.81501302621879401 -0.24129946708679206
1.9971439207037707 1.2954953163341505 -0.049152048263549859
2.0205142771490827 1.2847801661113722 -0.017448469848632919
1.5417907847174424 0.95561821321525398 -0.13990729354858411
1.4895828474005479 0.97378976877250489 -0.19392277557373058
2.0205142771490827 1.2847801661113722 -0.017448469848632919
2.0198935398443956 1.2740651418498976 0.013778345031738208
1.5411705512579692 0.94490306299247562 -0.10868104549407964
1.5417907847174424 0.95561821321525398 -0.13990729354858411
0.28241959331119232 1.2954953163341505 -0.083217590065002553
0.22642928996646544 1.2847801661113722 -0.053090732269287177
0.22642928996646544 1.2847801661113722 -0.053090732269287177
0.22580956035220764 1.2740651418498976 -0.021863917388916142
-0.040140349773524195 0.96633323747672861 -0.20257423877716071
-0.096132416576503288 0.95561808725395037 -0.17244741247177131
-0.096132416576503288 0.95561808725395037 -0.17244741247177131
-0.096752901958583076 0.9449029370311719 -0.14122062908172611
0.20012151591861418 0.81453978960075202 -0.26555637067794813
0.19770381465518616 0.77277738233604265 -0.14384950447082528
-0.040934409832118233 0.77758582914390384 -0.16260885845184331
-0.095685757793543866 0.788301042347334 -0.19493553594589244
1.5422376954230086 0.788301042347334 -0.16239592086792001
1.4880516617926374 0.77230427167930427 -0.11683533943176276
0.98631806224429786 0.77396324502982916 -0.1316389416503907
0.98859896953189541 0.81335411584892092 -0.24643472049713142
0.58383844310367261 0.76981149747886479 -0.12753090267181405
0.58660001872623146 0.81750573743858157 -0.26652491863250738
1.4905240302618756 0.81501302621879401 -0.24129946708679206
1.5428579288824815 0.79901612958946044 -0.19362267276763925
-0.095065524334071644 0.79901612958946044 -0.22616279169082645
-0.039073205608485706 0.80973140577354252 -0.25628964948654182
0.98631806224429786 0.77396324502982916 -0.1316389416503907
1.4880516617926374 0.77230427167930427 -0.11683533943176276
0.58383844310367261 0.76981149747886479 -0.12753090267181405
-0.042001553997157437 0.93418778680839354 -0.10889398307800302
-0.096752901958583076 0.9449029370311719 -0.14122062908172611
-0.095685757793543866 0.788301042347334 -0.19493553594589244
-0.040934409832118233 0.77758582914390384 -0.16260885845184331
1.4895828474005479 0.97378976877250489 -0.19392277557373058
1.5417907847174424 0.95561821321525398 -0.13990729354858411
1.5428579288824815 0.79901612958946044 -0.19362267276763925
1.4905240302618756 0.81501302621879401 -0.24129946708679206
1.5411705512579692 0.94490306299247562 -0.10868104549407964
1.4868585563238872 0.92673138147392109 -0.056781776351928819
1.4880516617926374 0.77230427167930427 -0.11683533943176276
1.5422376954230086 0.788301042347334 -0.16239592086792001
-0.096753153881190643 -1.1898101345630663 -0.14122062908172611
0.22580956035220764 -1.518972339381792 -0.021863917388916142
0.28055838908755976 -1.5082570631977099 0.010463673324584888
-0.042001805919765003 -1.179094984340288 -0.10889398307800302
1.4755895542486923 -2.7691327364154832 0.4319935540771484
1.5303419099005475 -2.7584645697589889 0.46418195755004876
2.0198935398443956 -1.5189722134204882 0.013778345031738208
1.5411705512579692 -1.1898100086017627 -0.10868104549407964
1.4868585563238872 -1.1716385790058153 -0.056781776351928819
1.9952827164801374 -1.5082569372364061 0.044529278106689378
0.58553237071597719 -1.2190150185962696 -0.21281001176834113
0.58659951488101636 -1.0624131239124315 -0.26652491863250738
0.98859846568668031 -1.0582613763614672 -0.24643472049713142
0.9875313215216418 -1.2148634599872605 -0.19271984512329113
1.2284675840338488 -1.5452593298145312 -0.078582025146484463
1.4895828474005479 -1.218697092265703 -0.19392277557373058
1.9971439207037707 -1.5404026398273485 -0.049152048263549859
0.50283373637759821 -1.5042634600635545 0.026522479934692311
0.19663641856754011 -1.174286852435686 -0.090134629096984983
-0.042001805919765003 -1.179094984340288 -0.10889398307800302
0.28055838908755976 -1.5082570631977099 0.010463673324584888
1.9952827164801374 -1.5082569372364061 0.044529278106689378
1.4868585563238872 -1.1716385790058153 -0.056781776351928819
0.98525041423404358 -1.1754723372455615 -0.077924066276550394
1.2260440885504504 -1.5034004991718308 0.043406459045410066
0.582770795093419 -1.1713205896945971 -0.073816027297973763
0.86790184062564557 -1.5012586531635301 0.042535562591552625
0.28241959331119232 -1.5404027657886523 -0.083217590065002553
-0.040140601696131761 -1.2112406869312304 -0.20257423877716071
0.19905462367618254 -1.2160490077777881 -0.21184045612335214
0.50515747050845816 -1.5443963689228075 -0.090436243438720795
0.87057322795474701 -1.5474011758228319 -0.091936316604614363
-0.096753153881190643 -1.1898101345630663 -0.14122062908172611
-0.095685757793543866 -1.033208365840532 -0.19493553594589244
-0.095065524334071644 -1.0439235160633105 -0.22616279169082645
-0.096132416576503288 -1.2005254107471484 -0.17244741247177131
0.20012151591861418 -1.0594470501132982 -0.26555637067794813
-0.096132416576503288 -1.2005254107471484 -0.17244741247177131
-0.095065524334071644 -1.0439235160633105 -0.22616279169082645
-0.039073205608485706 -1.0546387922473923 -0.25628964948654182
-0.040140601696131761 -1.2112406869312304 -0.20257423877716071
2.1805400519903912 -2.7918458267780317 0.37978070426940913
1.9268554978522077 -2.7936375003620162 0.36951819599151597
2.0205142771490827 -1.5296873636432664 -0.017448469848632919
2.5204556992682234 -2.7798003992267626 0.42165036758422836
2.4970833274420521 -2.7904675581928271 0.39008610237121571
1.9971439207037707 -1.5404026398273485 -0.049152048263549859
1.6809800406988873 -2.7566527423664109 0.47245774116516109
1.9246400904425398 -2.7553732274433149 0.48103003768920899
2.4952306885870708 -2.7584645697589889 0.48335125259399397
2.178533236499669 -2.7571649010272994 0.48085092071533186
2.3197363618048445 -3.0731718332477587 0.58785366264343253
2.3197363618048445 -3.0731718332477587 0.58785366264343253
2.3845872870978138 -3.0612634515949266 0.58505555824279765
2.4447045865973251 -3.0310498694416061 0.57588293014526359
2.4927890546759386 -2.9782965196796432 0.55873606979370105
2.5140603919562121 -2.9069656410785689 0.53468123962402336
2.5118036692389274 -2.8308625925251025 0.50852411529541008
1.5303419099005475 -2.7584645697589889 0.46418195755004876
1.8379263135870714 -3.0731718332477587 0.57828198913574202
1.9499613355597276 -3.0731718332477587 0.58050772537231432
2.1311143479498638 -3.0731718332477587 0.58410694366455074
1.799102016712071 -3.1064168001361865 0.55415737640380847
1.8379263135870714 -3.0731718332477587 0.57828198913574202
1.6830468137701768 -2.7923579854389207 0.36840532787322988
1.532194548755528 -2.7904675581928271 0.3709177520370483
2.4970833274420521 -2.7904675581928271 0.39008610237121571
1.799102016712071 -3.1064168001361865 0.55415737640380847
1.9665091239508403 -3.1064168001361865 0.5574819990539549
1.9499613355597276 -3.0731718332477587 0.58050772537231432
1.8379263135870714 -3.0731718332477587 0.57828198913574202
2.1476616324957623 -3.1064168001361865 0.56108121734619132
2.1311143479498638 -3.0731718332477587 0.58410694366455074
2.3362841501959579 -3.1064168001361865 0.56482806228637683
2.3197363618048445 -3.0731718332477587 0.58785366264343253
2.3215900083502552 -3.1051750736042036 0.49458851242065427
2.1329674906500595 -3.1051750736042036 0.49084065979003894
1.9518144782599225 -3.1051750736042036 0.4872424491882324
1.8397794562872662 -3.1051750736042036 0.48501671295166016
2.3369013605841413 -3.1170844629474654 0.53374056060790998
2.3215900083502552 -3.1051750736042036 0.49458851242065427
2.3864409336432235 -3.0932664400287644 0.49179040802001939
2.401750270496251 -3.1051760812946334 0.53094245620727532
2.4465577292975209 -3.0630531097980516 0.48261664627075185
2.4618700892218368 -3.0749624991413134 0.52176894638061511
2.4946421973761339 -3.0102997600360886 0.46546991188049308
2.5099540534552358 -3.0222086455341355 0.50462309371948233
2.5159125269659781 -2.9389686295124067 0.44141697113037098
2.5392879218634388 -2.9283009667011277 0.47298224403381339
2.5136568119391218 -2.8628658328815475 0.41525783142089828
2.5370296876105085 -2.8521979181476609 0.44682297836303708
2.5136568119391218 -2.8628658328815475 0.41525783142089828
2.5159125269659781 -2.9389686295124067 0.44141697113037098
2.4946421973761339 -3.0102997600360886 0.46546991188049308
2.4465577292975209 -3.0630531097980516 0.48261664627075185
2.3864409336432235 -3.0932664400287644 0.49179040802001939
2.5118036692389274 -2.8308625925251025 0.50852411529541008
2.5364124772223247 -2.8415307591815964 0.47791148773193354
2.5198384888800396 -2.7691327364154832 0.45273875099182126
2.4952306885870708 -2.7584645697589889 0.48335125259399397
2.5364124772223247 -2.8415307591815964 0.47791148773193354
2.5370296876105085 -2.8521979181476609 0.44682297836303708
2.5204556992682234 -2.7798003992267626 0.42165036758422836
2.5198384888800396 -2.7691327364154832 0.45273875099182126
2.5140603919562121 -2.9069656410785689 0.53468123962402336
2.53867020763004 -2.9176328000446334 0.50406961975097653
2.53867020763004 -2.9176328000446334 0.50406961975097653
2.5392879218634388 -2.9283009667011277 0.47298224403381339
2.4927890546759386 -2.9782965196796432 0.55873606979370105
2.5093363392218371 -3.0115409827228561 0.53571046943664546
2.5093363392218371 -3.0115409827228561 0.53571046943664546
2.5099540534552358 -3.0222086455341355 0.50462309371948233
2.4447045865973251 -3.0310498694416061 0.57588293014526359
2.461252878833653 -3.064294836330034 0.55285720382690429
2.461252878833653 -3.064294836330034 0.55285720382690429
2.4618700892218368 -3.0749624991413134 0.52176894638061511
2.5099540534552358 -3.0222086455341355 0.50462309371948233
2.5093363392218371 -3.0115409827228561 0.53571046943664546
2.3845872870978138 -3.0612634515949266 0.58505555824279765
2.4011330601080672 -3.0945086704059617 0.56203096557617183
2.4011330601080672 -3.0945086704059617 0.56203096557617183
2.401750270496251 -3.1051760812946334 0.53094245620727532
2.3362841501959579 -3.1064168001361865 0.56482806228637683
2.3369013605841413 -3.1170844629474654 0.53374056060790998
2.1329674906500595 -3.1051750736042036 0.49084065979003894
2.1482788428839457 -3.1170844629474654 0.52999295989990225
2.1482788428839457 -3.1170844629474654 0.52999295989990225
2.1476616324957623 -3.1064168001361865 0.56108121734619132
1.9518144782599225 -3.1051750736042036 0.4872424491882324
1.967126334339024 -3.1170844629474654 0.52639449737548816
1.967126334339024 -3.1170844629474654 0.52639449737548816
1.9665091239508403 -3.1064168001361865 0.5574819990539549
1.8397794562872662 -3.1051750736042036 0.48501671295166016
1.7997197309454698 -3.1170844629474654 0.52306886703491207
1.7997197309454698 -3.1170844629474654 0.52306886703491207
1.799102016712071 -3.1064168001361865 0.55415737640380847
1.532194548755528 -2.7904675581928271 0.3709177520370483
1.8397794562872662 -3.1051750736042036 0.48501671295166016
1.7997197309454698 -3.1170844629474654 0.52306886703491207
1.4762072684820904 -2.7798003992267626 0.40090529663085928
1.4762072684820904 -2.7798003992267626 0.40090529663085928
1.7997197309454698 -3.1170844629474654 0.52306886703491207
1.799102016712071 -3.1064168001361865 0.55415737640380847
1.4755895542486923 -2.7691327364154832 0.4319935540771484
1.9952827164801374 -1.5082569372364061 0.044529278106689378
2.0198935398443956 -1.5189722134204882 0.013778345031738208
2.0198935398443956 -1.5189722134204882 0.013778345031738208
2.0205142771490827 -1.5296873636432664 -0.017448469848632919
0.19770381465518616 -1.0176847058292406 -0.14384950447082528
-0.040934409832118233 -1.0224932785984058 -0.16260885845184331
-0.039073205608485706 -1.0546387922473923 -0.25628964948654182
1.5417907847174424 -1.2005252847858445 -0.13990729354858411
1.5428579288824815 -1.0439235790439623 -0.19362267276763925
1.5422371915777942 -1.033208428821184 -0.16239592086792001
1.5411705512579692 -1.1898100086017627 -0.10868104549407964
1.4905240302618756 -1.0599204756732958 -0.24129946708679206
1.9971439207037707 -1.5404026398273485 -0.049152048263549859
1.4895828474005479 -1.218697092265703 -0.19392277557373058
1.5417907847174424 -1.2005252847858445 -0.13990729354858411
2.0205142771490827 -1.5296873636432664 -0.017448469848632919
2.0205142771490827 -1.5296873636432664 -0.017448469848632919
1.5417907847174424 -1.2005252847858445 -0.13990729354858411
1.5411705512579692 -1.1898100086017627 -0.10868104549407964
2.0198935398443956 -1.5189722134204882 0.013778345031738208
0.28241959331119232 -1.5404027657886523 -0.083217590065002553
0.22642928996646544 -1.5296874896045702 -0.053090732269287177
0.22642928996646544 -1.5296874896045702 -0.053090732269287177
0.22580956035220764 -1.518972339381792 -0.021863917388916142
-0.040140601696131761 -1.2112406869312304 -0.20257423877716071
-0.096132416576503288 -1.2005254107471484 -0.17244741247177131
-0.096132416576503288 -1.2005254107471484 -0.17244741247177131
-0.096753153881190643 -1.1898101345630663 -0.14122062908172611
0.20012151591861418 -1.0594470501132982 -0.26555637067794813
-0.095685757793543866 -1.033208365840532 -0.19493553594589244
-0.040934409832118233 -1.0224932785984058 -0.16260885845184331
0.19770381465518616 -1.0176847058292406 -0.14384950447082528
1.5422371915777942 -1.033208428821184 -0.16239592086792001
0.98859846568668031 -1.0582613763614672 -0.24643472049713142
0.98631755839908275 -1.0188704425617237 -0.1316389416503907
1.4880516617926374 -1.0172117211338061 -0.11683533943176276
0.58659951488101636 -1.0624131239124315 -0.26652491863250738
0.58383844310367261 -1.0147189469333666 -0.12753090267181405
1.4905240302618756 -1.0599204756732958 -0.24129946708679206
1.5428579288824815 -1.0439235790439623 -0.19362267276763925
0.20012151591861418 -1.0594470501132982 -0.26555637067794813
-0.039073205608485706 -1.0546387922473923 -0.25628964948654182
-0.095065524334071644 -1.0439235160633105 -0.22616279169082645
1.4880516617926374 -1.0172117211338061 -0.11683533943176276
0.98631755839908275 -1.0188704425617237 -0.1316389416503907
0.58383844310367261 -1.0147189469333666 -0.12753090267181405
-0.042001805919765003 -1.179094984340288 -0.10889398307800302
-0.040934409832118233 -1.0224932785984058 -0.16260885845184331
-0.095685757793543866 -1.033208365840532 -0.19493553594589244
-0.096753153881190643 -1.1898101345630663 -0.14122062908172611
1.4895828474005479 -1.218697092265703 -0.19392277557373058
1.4905240302618756 -1.0599204756732958 -0.24129946708679206
1.5428579288824815 -1.0439235790439623 -0.19362267276763925
1.5417907847174424 -1.2005252847858445 -0.13990729354858411
1.5411705512579692 -1.1898100086017627 -0.10868104549407964
1.5422371915777942 -1.033208428821184 -0.16239592086792001
1.4880516617926374 -1.0172117211338061 -0.11683533943176276
1.4868585563238872 -1.1716385790058153 -0.056781776351928819
1
SmallPart
4334 3
1 2 3 0 0
3 4 1 0 0
5 6 7 0 0
7 8 5 0 0
9 10 11 0 0
11 12 9 0 0
13 14 15 0 0
16 17 18 0 0
18 19 16 0 0
20 21 22 0 0
22 23 20 0 0
24 25 26 0 0
26 27 24 0 0
28 29 30 0 0
30 31 28 0 0
32 33 34 0 0
34 35 32 0 0
36 37 38 0 0
38 39 36 0 0
40 41 42 0 0
42 43 40 0 0
44 45 46 0 0
46 47 44 0 0
48 49 50 0 0
50 51 48 0 0
52 53 54 0 0
54 55 52 0 0
56 57 58 0 0
58 59 56 0 0
60 61 62 0 0
63 64 65 0 0
65 66 63 0 0
67 68 69 0 0
69 70 67 0 0
71 72 73 0 0
73 74 71 0 0
75 76 77 0 0
77 78 75 0 0
79 80 81 0 0
81 82 79 0 0
83 84 85 0 0
85 86 83 0 0
87 88 89 0 0
89 90 87 0 0
91 92 93 0 0
93 94 91 0 0
88 87 95 0 0
95 96 88 0 0
97 98 99 0 0
99 100 97 0 0
48 101 102 0 0
102 49 48 0 0
103 104 105 0 0
105 106 103 0 0
107 2 108 0 0
108 23 107 0 0
109 110 111 0 0
111 112 109 0 0
41 113 114 0 0
114 42 41 0 0
115 116 117 0 0
117 118 115 0 0
119 120 121 0 0
121 122 119 0 0
123 124 125 0 0
125 126 123 0 0
127 128 129 0 0
129 130 127 0 0
131 132 133 0 0
133 134 131 0 0
135 136 137 0 0
137 138 135 0 0
139 140 141 0 0
141 142 139 0 0
143 144 145 0 0
146 147 148 0 0
45 149 150 0 0
150 46 45 0 0
151 152 153 0 0
153 154 151 0 0
155 156 157 0 0
157 158 155 0 0
159 160 161 0 0
161 162 159 0 0
163 164 98 0 0
98 97 163 0 0
165 166 167 0 0
167 168 165 0 0
169 170 171 0 0
171 172 169 0 0
173 174 175 0 0
175 176 173 0 0
177 178 179 0 0
179 180 177 0 0
181 182 173 0 0
173 183 181 0 0
184 185 186 0 0
186 187 184 0 0
188 189 190 0 0
190 191 188 0 0
192 193 194 0 0
194 195 192 0 0
196 197 198 0 0
198 199 196 0 0
200 201 202 0 0
202 203 200 0 0
10 204 205 0 0
205 11 10 0 0
206 207 208 0 0
208 209 206 0 0
210 211 212 0 0
212 213 210 0 0
214 215 216 0 0
216 217 214 0 0
218 219 220 0 0
220 221 218 0 0
219 222 223 0 0
223 220 219 0 0
179 224 225 0 0
225 226 179 0 0
227 228 229 0 0
229 230 227 0 0
231 232 233 0 0
233 234 231 0 0
235 236 237 0 0
237 238 235 0 0
239 240 241 0 0
241 242 239 0 0
243 244 245 0 0
245 246 243 0 0
247 248 126 0 0
126 125 247 0 0
249 166 250 0 0
250 251 249 0 0
252 253 254 0 0
254 255 252 0 0
256 257 258 0 0
258 259 256 0 0
260 261 189 0 0
189 188 260 0 0
238 218 221 0 0
221 235 238 0 0
204 262 263 0 0
263 205 204 0 0
264 265 266 0 0
266 267 264 0 0
268 269 270 0 0
270 271 268 0 0
126 272 273 0 0
273 123 126 0 0
274 275 276 0 0
276 277 274 0 0
278 279 280 0 0
280 281 278 0 0
282 283 284 0 0
249 251 285 0 0
285 286 249 0 0
214 217 287 0 0
287 288 214 0 0
289 290 291 0 0
291 292 289 0 0
293 294 295 0 0
295 296 293 0 0
297 298 299 0 0
299 300 297 0 0
301 302 303 0 0
303 304 301 0 0
305 306 307 0 0
307 308 305 0 0
309 310 311 0 0
311 312 309 0 0
139 313 314 0 0
314 315 139 0 0
316 252 255 0 0
255 317 316 0 0
318 319 320 0 0
320 224 318 0 0
321 322 323 0 0
323 324 321 0 0
325 326 327 0 0
327 328 325 0 0
137 329 330 0 0
330 331 137 0 0
332 333 334 0 0
334 335 332 0 0
336 337 338 0 0
338 339 336 0 0
340 341 342 0 0
342 64 340 0 0
224 320 343 0 0
343 225 224 0 0
344 345 346 0 0
346 347 344 0 0
348 349 350 0 0
350 351 348 0 0
352 353 354 0 0
354 355 352 0 0
356 357 358 0 0
358 359 356 0 0
185 360 361 0 0
361 186 185 0 0
362 363 364 0 0
364 365 362 0 0
43 20 23 0 0
23 40 43 0 0
84 366 367 0 0
367 85 84 0 0
368 369 370 0 0
370 371 368 0 0
372 373 374 0 0
374 375 376 0 0
377 378 302 0 0
302 379 377 0 0
380 381 382 0 0
382 132 380 0 0
383 384 385 0 0
385 386 383 0 0
387 388 389 0 0
389 390 387 0 0
194 391 392 0 0
392 345 194 0 0
393 394 395 0 0
395 396 393 0 0
160 397 398 0 0
398 161 160 0 0
399 400 401 0 0
401 402 399 0 0
295 403 404 0 0
404 177 295 0 0
405 131 134 0 0
134 406 405 0 0
407 408 117 0 0
117 409 407 0 0
410 411 412 0 0
412 413 410 0 0
414 415 416 0 0
416 417 414 0 0
418 419 420 0 0
420 421 418 0 0
422 423 424 0 0
424 425 422 0 0
426 427 428 0 0
248 429 272 0 0
272 126 248 0 0
430 1 4 0 0
4 431 430 0 0
411 406 432 0 0
432 412 411 0 0
332 335 433 0 0
433 434 332 0 0
435 436 437 0 0
437 438 435 0 0
137 136 439 0 0
439 329 137 0 0
440 441 442 0 0
442 443 440 0 0
444 445 446 0 0
446 447 444 0 0
447 61 448 0 0
449 450 447 0 0
305 451 452 0 0
452 306 305 0 0
453 454 455 0 0
31 456 453 0 0
4 3 457 0 0
457 458 4 0 0
459 294 460 0 0
460 461 459 0 0
13 15 462 0 0
463 446 464 0 0
465 466 467 0 0
468 447 446 0 0
446 463 468 0 0
469 305 308 0 0
308 470 469 0 0
471 472 473 0 0
474 473 475 0 0
476 477 478 0 0
479 480 481 0 0
482 483 484 0 0
485 473 486 0 0
487 473 488 0 0
489 473 490 0 0
490 473 491 0 0
492 493 494 0 0
495 473 496 0 0
497 473 498 0 0
496 473 497 0 0
499 473 500 0 0
501 502 503 0 0
504 505 502 0 0
506 507 508 0 0
509 473 485 0 0
510 511 512 0 0
513 514 515 0 0
516 517 518 0 0
519 520 521 0 0
491 473 522 0 0
523 524 525 0 0
526 473 495 0 0
527 528 529 0 0
314 313 318 0 0
318 178 314 0 0
530 473 531 0 0
532 533 534 0 0
535 473 489 0 0
488 473 509 0 0
536 537 523 0 0
538 539 473 0 0
540 541 542 0 0
543 544 545 0 0
546 473 530 0 0
474 538 473 0 0
498 473 487 0 0
475 473 547 0 0
548 549 550 0 0
551 471 473 0 0
552 473 526 0 0
553 554 555 0 0
486 473 556 0 0
551 473 552 0 0
557 558 559 0 0
547 473 560 0 0
561 562 563 0 0
560 473 535 0 0
522 473 499 0 0
539 564 473 0 0
556 473 564 0 0
531 473 472 0 0
565 566 567 0 0
568 569 570 0 0
500 473 546 0 0
571 572 573 0 0
574 575 576 0 0
140 139 315 0 0
315 577 140 0 0
578 579 580 0 0
581 582 583 0 0
584 585 586 0 0
587 588 589 0 0
589 590 587 0 0
591 592 593 0 0
594 595 596 0 0
597 598 599 0 0
600 601 597 0 0
602 603 604 0 0
604 603 605 0 0
606 607 608 0 0
609 610 611 0 0
477 612 600 0 0
613 614 615 0 0
610 616 611 0 0
617 618 619 0 0
620 621 617 0 0
622 623 624 0 0
625 626 627 0 0
579 628 580 0 0
629 630 617 0 0
629 617 619 0 0
631 632 605 0 0
631 605 633 0 0
634 630 635 0 0
636 637 638 0 0
639 640 641 0 0
642 643 644 0 0
645 646 647 0 0
648 649 282 0 0
650 651 652 0 0
653 478 654 0 0
655 656 657 0 0
658 659 660 0 0
661 662 663 0 0
664 665 666 0 0
667 666 665 0 0
668 669 670 0 0
671 672 673 0 0
674 675 676 0 0
675 677 678 0 0
627 679 677 0 0
625 675 674 0 0
680 681 682 0 0
683 684 685 0 0
686 687 688 0 0
689 690 691 0 0
692 693 694 0 0
695 696 697 0 0
698 699 700 0 0
701 702 703 0 0
704 705 706 0 0
707 704 706 0 0
706 705 708 0 0
704 707 709 0 0
707 710 709 0 0
711 428 427 0 0
426 710 707 0 0
710 426 428 0 0
712 713 714 0 0
715 716 717 0 0
718 719 720 0 0
721 722 723 0 0
724 725 726 0 0
725 727 728 0 0
716 729 730 0 0
727 731 728 0 0
729 721 730 0 0
732 733 672 0 0
670 734 735 0 0
640 736 737 0 0
736 640 639 0 0
662 639 641 0 0
639 662 661 0 0
738 739 740 0 0
713 741 704 0 0
701 703 636 0 0
636 703 637 0 0
702 741 713 0 0
742 743 744 0 0
745 746 747 0 0
747 748 745 0 0
749 750 751 0 0
752 753 581 0 0
752 754 753 0 0
755 756 757 0 0
758 759 760 0 0
759 758 761 0 0
761 758 762 0 0
763 764 765 0 0
660 766 767 0 0
580 628 768 0 0
628 769 768 0 0
770 771 772 0 0
773 774 775 0 0
776 774 777 0 0
778 774 779 0 0
292 774 780 0 0
771 774 781 0 0
782 774 783 0 0
784 774 785 0 0
786 774 782 0 0
783 774 776 0 0
780 774 773 0 0
777 774 778 0 0
787 774 771 0 0
785 774 788 0 0
781 774 786 0 0
775 774 787 0 0
779 774 784 0 0
789 790 791 0 0
792 793 794 0 0
795 796 797 0 0
797 798 795 0 0
799 800 801 0 0
802 803 804 0 0
805 806 807 0 0
807 808 805 0 0
809 810 811 0 0
811 812 809 0 0
813 75 78 0 0
78 814 815 0 0
816 817 818 0 0
816 819 820 0 0
821 822 823 0 0
824 825 826 0 0
827 828 829 0 0
830 828 827 0 0
745 831 44 0 0
44 746 745 0 0
832 833 834 0 0
834 835 832 0 0
836 837 838 0 0
838 839 840 0 0
841 842 843 0 0
844 819 845 0 0
844 842 820 0 0
846 36 847 0 0
848 849 850 0 0
851 852 853 0 0
64 342 854 0 0
854 65 64 0 0
855 856 857 0 0
855 858 859 0 0
860 96 861 0 0
589 862 353 0 0
863 590 352 0 0
864 865 866 0 0
865 867 868 0 0
869 870 866 0 0
871 872 867 0 0
873 874 875 0 0
876 877 878 0 0
879 876 512 0 0
880 881 882 0 0
883 884 885 0 0
886 887 888 0 0
889 890 891 0 0
892 893 894 0 0
895 896 897 0 0
898 899 883 0 0
900 901 902 0 0
903 904 905 0 0
885 898 883 0 0
905 906 903 0 0
907 908 909 0 0
910 911 912 0 0
913 34 33 0 0
914 915 916 0 0
917 359 918 0 0
919 355 354 0 0
347 788 774 0 0
920 921 922 0 0
923 924 925 0 0
926 927 928 0 0
929 930 931 0 0
931 932 929 0 0
933 934 935 0 0
935 936 933 0 0
937 938 939 0 0
939 940 937 0 0
941 307 942 0 0
942 943 941 0 0
944 945 946 0 0
946 947 944 0 0
948 119 122 0 0
122 165 948 0 0
812 811 949 0 0
949 290 812 0 0
950 951 952 0 0
952 953 950 0 0
154 153 954 0 0
954 955 956 0 0
954 956 154 0 0
62 957 958 0 0
958 337 62 0 0
421 420 959 0 0
959 960 421 0 0
961 296 180 0 0
180 962 961 0 0
963 964 965 0 0
966 967 963 0 0
402 968 969 0 0
969 970 402 0 0
197 971 972 0 0
972 198 197 0 0
973 974 228 0 0
228 975 973 0 0
976 977 978 0 0
978 979 976 0 0
980 981 588 0 0
588 587 980 0 0
982 983 984 0 0
984 985 982 0 0
986 987 988 0 0
988 989 986 0 0
945 990 991 0 0
991 946 945 0 0
38 103 106 0 0
106 992 38 0 0
993 994 995 0 0
995 996 993 0 0
997 998 999 0 0
999 174 997 0 0
1000 85 367 0 0
367 1001 1000 0 0
1002 601 1003 0 0
1003 209 1002 0 0
458 1004 431 0 0
431 4 458 0 0
1005 207 26 0 0
1006 307 306 0 0
476 1007 477 0 0
1008 1009 774 0 0
1010 1011 1012 0 0
1012 1013 1010 0 0
1014 1015 1016 0 0
1017 26 25 0 0
1018 1019 1020 0 0
1021 609 1022 0 0
1022 77 1021 0 0
1003 1023 1024 0 0
600 612 601 0 0
799 801 1025 0 0
637 1026 638 0 0
653 476 478 0 0
1027 1028 1029 0 0
671 732 672 0 0
715 1030 716 0 0
731 1031 719 0 0
721 1032 722 0 0
724 1033 725 0 0
725 1033 727 0 0
716 1030 729 0 0
727 1031 731 0 0
729 1032 721 0 0
732 1034 733 0 0
670 669 734 0 0
1035 1036 751 0 0
1036 749 751 0 0
1037 580 768 0 0
769 628 1038 0 0
1038 1039 769 0 0
1040 1041 774 0 0
1042 775 787 0 0
1043 13 462 0 0
462 1044 1043 0 0
1045 1046 1047 0 0
1048 1049 800 0 0
191 1050 1051 0 0
1051 748 191 0 0
1052 196 199 0 0
199 1053 1052 0 0
816 820 817 0 0
816 1054 819 0 0
122 121 1055 0 0
1055 1056 122 0 0
383 386 1057 0 0
1057 1058 383 0 0
841 1059 856 0 0
841 859 1060 0 0
844 820 819 0 0
844 843 842 0 0
1061 1062 1063 0 0
1063 1064 1061 0 0
1065 1066 1067 0 0
1068 1041 1040 0 0
296 295 177 0 0
177 180 296 0 0
855 1069 858 0 0
1070 375 1071 0 0
865 864 867 0 0
886 1072 887 0 0
899 889 891 0 0
1073 115 118 0 0
895 1074 896 0 0
907 1075 908 0 0
1076 1077 1078 0 0
1079 1080 1081 0 0
1082 839 1083 0 0
1084 1008 774 0 0
823 822 1085 0 0
1086 1087 1088 0 0
1089 608 607 0 0
1090 1091 1092 0 0
1093 1094 1086 0 0
1095 812 290 0 0
290 289 1095 0 0
824 1096 825 0 0
1097 1098 1099 0 0
914 1100 1101 0 0
1102 1103 1104 0 0
1105 192 774 0 0
1041 1106 774 0 0
1107 1108 1109 0 0
1110 1111 1112 0 0
1113 1114 1115 0 0
1116 419 418 0 0
1117 1118 1119 0 0
1120 1121 1118 0 0
516 518 1122 0 0
1123 1124 1125 0 0
421 960 400 0 0
1126 1127 1118 0 0
46 150 1128 0 0
302 1129 1130 0 0
1131 1132 1118 0 0
47 746 44 0 0
1133 1134 1135 0 0
84 83 1136 0 0
1111 1110 1137 0 0
1137 1138 1111 0 0
1139 1140 1141 0 0
338 337 958 0 0
1142 1118 1117 0 0
1116 366 419 0 0
1143 1144 1145 0 0
1146 1145 1147 0 0
1148 1149 1118 0 0
1132 1150 1118 0 0
1151 1152 1153 0 0
1152 456 31 0 0
1154 56 454 0 0
1155 456 1156 0 0
511 1113 1115 0 0
1115 1157 511 0 0
1158 1159 1160 0 0
1161 1162 1163 0 0
1164 1165 1166 0 0
1167 1168 1169 0 0
1169 1170 1167 0 0
1171 1164 1172 0 0
1157 1173 1174 0 0
1174 1175 1176 0 0
1177 1171 1178 0 0
1179 1180 1181 0 0
1182 1183 1184 0 0
1185 1172 1182 0 0
1174 1176 1186 0 0
1185 1187 1188 0 0
1186 1176 1189 0 0
1190 1191 1192 0 0
1192 1193 1190 0 0
1194 1195 1196 0 0
1196 1197 1194 0 0
1198 1199 251 0 0
251 250 1198 0 0
1200 1201 1202 0 0
1202 1203 1200 0 0
1204 1205 567 0 0
567 566 1204 0 0
1175 1174 1173 0 0
1173 1206 1175 0 0
1149 1207 1118 0 0
1208 1209 1210 0 0
1210 1211 1208 0 0
1212 1213 1214 0 0
1214 1215 1212 0 0
1039 1216 1217 0 0
1217 769 1039 0 0
1218 1219 1220 0 0
1220 1221 1218 0 0
1222 1223 1224 0 0
1224 1225 1222 0 0
335 334 1226 0 0
1226 1227 335 0 0
1021 77 76 0 0
76 1228 1021 0 0
1229 1230 1231 0 0
1113 510 1232 0 0
1232 1114 1113 0 0
282 1233 283 0 0
1234 493 1235 0 0
1235 1236 1234 0 0
1237 1024 1023 0 0
1238 1239 1240 0 0
831 1241 1141 0 0
1141 1140 831 0 0
1242 1243 1244 0 0
1245 1246 1242 0 0
1247 1212 1215 0 0
1215 1248 1247 0 0
410 1249 1250 0 0
1250 1251 410 0 0
776 777 1252 0 0
1252 1253 776 0 0
1254 1255 1118 0 0
1256 1257 1258 0 0
1258 1259 1256 0 0
24 588 981 0 0
981 25 24 0 0
1260 1261 1262 0 0
1262 1263 1264 0 0
157 1265 1266 0 0
1266 158 157 0 0
1199 1001 970 0 0
970 969 1199 0 0
1267 1268 232 0 0
232 231 1267 0 0
1269 1270 1271 0 0
1272 1273 1274 0 0
1274 1275 1272 0 0
282 649 1276 0 0
1276 1277 282 0 0
1278 1279 1280 0 0
1280 1281 1278 0 0
1282 1018 1020 0 0
1020 543 1282 0 0
545 544 1014 0 0
1014 568 545 0 0
1283 1284 1285 0 0
1285 1286 1283 0 0
32 35 359 0 0
359 917 32 0 0
1287 1288 1289 0 0
1289 1290 1287 0 0
1291 1292 1293 0 0
1293 1294 1291 0 0
623 622 1295 0 0
1295 1296 623 0 0
696 695 1297 0 0
1297 1298 696 0 0
1299 1300 1301 0 0
1301 1302 1299 0 0
1303 1304 1305 0 0
1305 1306 1303 0 0
1307 1294 1308 0 0
1308 1309 1307 0 0
1231 70 1310 0 0
1310 1229 1231 0 0
627 677 675 0 0
675 625 627 0 0
1311 1123 1125 0 0
1125 1312 1313 0 0
1314 1190 1193 0 0
1193 1315 1314 0 0
450 1316 1317 0 0
139 142 1318 0 0
1318 313 139 0 0
1319 1320 1321 0 0
1321 503 1319 0 0
602 600 597 0 0
597 599 602 0 0
1322 1323 1324 0 0
1324 1325 1322 0 0
1326 1327 1328 0 0
1329 1330 1331 0 0
1332 404 403 0 0
403 1333 1332 0 0
766 660 1334 0 0
1334 1335 766 0 0
1336 1337 1338 0 0
1339 1340 1336 0 0
1341 1342 1343 0 0
1343 1344 1341 0 0
1345 1346 1347 0 0
1347 1348 1345 0 0
222 1349 1350 0 0
1350 223 222 0 0
1351 1352 1353 0 0
1353 1354 1351 0 0
679 680 682 0 0
682 677 679 0 0
1355 1356 1357 0 0
1357 1358 1355 0 0
1359 1360 1361 0 0
1361 1362 1359 0 0
1363 1364 1365 0 0
1365 1366 1363 0 0
1367 451 807 0 0
807 806 1367 0 0
1236 1235 1368 0 0
1368 1369 1236 0 0
1370 1371 1289 0 0
1289 1288 1370 0 0
1002 1321 1320 0 0
1320 598 1002 0 0
1372 1373 1374 0 0
1374 1375 1372 0 0
56 59 29 0 0
29 28 56 0 0
649 648 1376 0 0
1376 737 649 0 0
1377 1378 1379 0 0
1379 1380 1377 0 0
1381 1196 1195 0 0
1195 1382 1381 0 0
934 933 1383 0 0
1383 1384 934 0 0
646 1385 1386 0 0
1386 647 646 0 0
1387 1388 1389 0 0
1390 170 1391 0 0
1392 529 1393 0 0
1393 1394 1392 0 0
1395 1396 1397 0 0
1397 1398 1395 0 0
1399 1400 1401 0 0
1401 1402 1399 0 0
1403 1334 660 0 0
660 659 1403 0 0
1404 1405 1406 0 0
1406 1407 1404 0 0
362 365 1408 0 0
1408 51 362 0 0
1409 1410 1356 0 0
1356 1411 1409 0 0
1412 1413 1414 0 0
1358 1357 1412 0 0
1415 1416 124 0 0
124 123 1415 0 0
1417 1418 1419 0 0
1419 1420 1417 0 0
1421 1422 1411 0 0
1411 1423 1421 0 0
1424 120 1425 0 0
1425 1426 1424 0 0
1427 1428 1429 0 0
1429 1430 1427 0 0
1431 1432 1433 0 0
1433 1434 1431 0 0
1435 1436 916 0 0
354 353 1437 0 0
265 1438 1439 0 0
1439 266 265 0 0
1440 1441 577 0 0
577 315 1332 0 0
1396 1442 1443 0 0
1443 1397 1396 0 0
1444 1445 1446 0 0
1446 1401 1444 0 0
1447 1448 1449 0 0
1449 1450 1447 0 0
1451 1452 1453 0 0
1453 1454 1451 0 0
758 760 1455 0 0
1455 1456 758 0 0
1457 1458 1459 0 0
1459 1373 1460 0 0
1461 1462 1463 0 0
1463 1464 1461 0 0
1465 1466 1467 0 0
1467 1468 1465 0 0
1469 1470 279 0 0
279 278 1469 0 0
513 1471 566 0 0
566 565 513 0 0
1472 1473 1474 0 0
1474 1475 1472 0 0
1476 1477 1478 0 0
1478 1479 1476 0 0
1480 1101 1481 0 0
1481 1482 1480 0 0
346 63 66 0 0
66 1483 346 0 0
1484 1485 1486 0 0
1486 1487 1484 0 0
1488 1489 1490 0 0
1490 1491 1488 0 0
61 60 1492 0 0
1492 1493 61 0 0
1494 1495 1496 0 0
1496 1497 1494 0 0
1498 1313 1312 0 0
1312 1499 1498 0 0
1500 1501 1502 0 0
1502 1503 1500 0 0
1504 1505 1506 0 0
1506 1507 1504 0 0
1088 1508 1509 0 0
1509 1510 1088 0 0
182 997 174 0 0
174 173 182 0 0
335 1227 1511 0 0
1511 433 335 0 0
1512 1513 1514 0 0
1514 1515 1512 0 0
1516 1517 1518 0 0
1518 1519 1516 0 0
1252 1218 1221 0 0
1221 1520 1252 0 0
577 1382 1521 0 0
1521 140 577 0 0
1522 1523 1524 0 0
1524 1525 1522 0 0
1526 1527 919 0 0
1528 912 1529 0 0
197 1530 1531 0 0
1531 971 197 0 0
635 1200 1203 0 0
1203 1532 635 0 0
1533 1534 1535 0 0
1535 1536 1533 0 0
946 991 1323 0 0
1323 1537 946 0 0
1538 1539 1540 0 0
1540 1541 1538 0 0
1542 1543 1544 0 0
957 1093 147 0 0
1001 1199 1198 0 0
1198 1000 1001 0 0
1545 1546 1547 0 0
1547 193 1545 0 0
1548 1549 819 0 0
819 1054 1548 0 0
1550 1551 1552 0 0
1552 1553 1550 0 0
1554 1555 261 0 0
261 260 1554 0 0
1556 288 287 0 0
287 1557 1556 0 0
1558 941 943 0 0
943 1559 1558 0 0
1560 1561 1562 0 0
1562 129 1560 0 0
1563 1179 528 0 0
528 1564 1563 0 0
1565 837 836 0 0
1566 1079 1081 0 0
1567 1568 1569 0 0
1569 1570 1567 0 0
280 1571 1572 0 0
1572 281 280 0 0
1573 1574 1575 0 0
1575 1576 1573 0 0
1577 1088 1087 0 0
1087 1578 1577 0 0
1579 1580 1581 0 0
1581 1582 1579 0 0
392 340 64 0 0
64 63 392 0 0
958 145 1583 0 0
1583 338 958 0 0
1584 1585 1553 0 0
1553 1552 1584 0 0
1116 418 399 0 0
399 1586 1116 0 0
1413 1412 149 0 0
149 45 1413 0 0
986 1425 120 0 0
120 119 986 0 0
1587 1588 1292 0 0
1292 1291 1587 0 0
398 1589 273 0 0
273 1470 398 0 0
1590 1591 717 0 0
717 716 1590 0 0
1592 227 230 0 0
230 1593 1592 0 0
132 131 396 0 0
396 380 132 0 0
1594 1595 182 0 0
182 181 1594 0 0
85 1000 1596 0 0
1596 86 85 0 0
952 1597 1084 0 0
1084 1106 952 0 0
1598 1599 1600 0 0
1600 1601 1598 0 0
971 1531 397 0 0
397 160 971 0 0
1602 1603 1604 0 0
1604 1605 1602 0 0
1606 1177 1178 0 0
1178 1607 1606 0 0
451 1608 1609 0 0
8 1610 1611 0 0
1611 1612 8 0 0
1613 1614 1615 0 0
1615 1616 1613 0 0
1295 1617 1618 0 0
1618 1296 1295 0 0
1619 1620 1621 0 0
1621 1622 1619 0 0
1623 1105 774 0 0
45 44 831 0 0
831 1140 45 0 0
1624 1625 1626 0 0
1626 1627 1624 0 0
972 971 160 0 0
160 159 972 0 0
1628 1118 1629 0 0
1630 1631 1632 0 0
1632 1251 1630 0 0
413 412 1633 0 0
1633 1634 413 0 0
1635 1636 1637 0 0
1637 1638 1635 0 0
1639 1640 1641 0 0
1641 1642 1639 0 0
1643 1644 1645 0 0
1645 1646 1643 0 0
165 122 1056 0 0
1056 166 165 0 0
1089 607 862 0 0
862 589 1089 0 0
1647 1648 1403 0 0
1403 659 1647 0 0
639 1649 1650 0 0
1650 736 639 0 0
1651 1652 1107 0 0
1107 1653 1651 0 0
1654 1655 1656 0 0
1656 1657 1654 0 0
1658 1420 1659 0 0
1660 540 1392 0 0
1392 1661 1660 0 0
548 1662 1277 0 0
1277 1276 548 0 0
27 608 1089 0 0
1089 24 27 0 0
1663 536 1664 0 0
1664 1665 1663 0 0
1666 1667 333 0 0
333 332 1666 0 0
1668 1669 1670 0 0
1670 1671 1668 0 0
1325 1324 1672 0 0
1672 1673 1325 0 0
977 976 1674 0 0
1675 1492 60 0 0
1609 1676 1677 0 0
767 1678 1679 0 0
1679 1680 767 0 0
1681 1247 1248 0 0
1248 1682 1681 0 0
71 74 1683 0 0
1684 1685 1686 0 0
1686 1687 1684 0 0
1688 1689 1690 0 0
1690 1691 1688 0 0
1692 1693 674 0 0
674 676 1692 0 0
1694 1695 1696 0 0
1696 1697 1694 0 0
810 1592 1698 0 0
1698 811 810 0 0
987 986 119 0 0
119 948 987 0 0
1699 1700 1701 0 0
1701 1702 1699 0 0
460 294 293 0 0
293 1703 460 0 0
1704 1705 1568 0 0
1568 1567 1704 0 0
1706 1707 1708 0 0
1708 1521 1706 0 0
1709 1710 1711 0 0
1711 1712 1709 0 0
435 1713 1714 0 0
1714 436 435 0 0
703 1715 1026 0 0
1026 637 703 0 0
1716 1717 974 0 0
974 973 1716 0 0
1718 1719 1720 0 0
1720 1721 1718 0 0
1694 1722 1723 0 0
1723 1695 1694 0 0
542 1724 527 0 0
527 529 542 0 0
1704 1567 1725 0 0
1725 661 1704 0 0
1726 1727 124 0 0
124 1416 1726 0 0
1728 1424 1426 0 0
1426 1154 1728 0 0
1729 1730 1731 0 0
1731 1732 1729 0 0
1733 1208 1734 0 0
1734 1735 1733 0 0
1546 1322 1325 0 0
1325 1547 1546 0 0
1736 1737 1738 0 0
1738 1739 1736 0 0
1344 1343 648 0 0
648 1740 1344 0 0
1741 876 879 0 0
879 1563 1741 0 0
1288 1287 1742 0 0
1742 1668 1288 0 0
1743 1744 540 0 0
540 1660 1743 0 0
1583 1745 339 0 0
339 338 1583 0 0
188 191 748 0 0
748 747 188 0 0
168 167 1746 0 0
1746 1747 168 0 0
1748 1749 1750 0 0
1750 1751 1748 0 0
1752 1753 1754 0 0
1754 1700 1752 0 0
990 1755 1756 0 0
1756 991 990 0 0
612 1757 1003 0 0
1003 601 612 0 0
1758 1759 1760 0 0
1760 1761 1758 0 0
553 638 1762 0 0
1762 554 553 0 0
1763 1764 1765 0 0
1765 1766 1763 0 0
1767 1768 1512 0 0
1512 585 1767 0 0
320 1431 1434 0 0
1434 343 320 0 0
1520 1221 1769 0 0
1769 1770 1520 0 0
1771 1772 87 0 0
87 90 1771 0 0
1773 1774 1775 0 0
1775 1776 1773 0 0
311 1589 398 0 0
398 397 311 0 0
1290 1289 814 0 0
814 1777 1290 0 0
1750 1778 1779 0 0
1779 1751 1750 0 0
1780 1781 1782 0 0
1782 1384 1780 0 0
1670 1669 1610 0 0
1610 1783 1670 0 0
1784 210 213 0 0
213 1785 1784 0 0
1737 1242 1246 0 0
1246 1738 1737 0 0
1782 1535 1534 0 0
1534 1786 1782 0 0
1787 1488 1491 0 0
1491 1788 1787 0 0
1335 1789 1790 0 0
1790 766 1335 0 0
1791 968 402 0 0
402 401 1791 0 0
1792 1793 363 0 0
363 362 1792 0 0
351 113 430 0 0
430 348 351 0 0
463 464 1794 0 0
1794 1795 463 0 0
1796 1797 1798 0 0
1798 1774 1796 0 0
1799 395 394 0 0
394 1241 1799 0 0
807 305 469 0 0
469 808 807 0 0
1800 1780 1384 0 0
1384 1383 1800 0 0
1430 1801 1802 0 0
1802 1803 1430 0 0
1804 1805 281 0 0
281 1572 1804 0 0
1803 1802 1806 0 0
1806 1807 1803 0 0
548 550 1808 0 0
1808 1809 548 0 0
1810 1702 1811 0 0
1811 1812 1810 0 0
438 437 975 0 0
975 1813 438 0 0
1251 1632 411 0 0
411 410 1251 0 0
1527 400 960 0 0
960 355 1527 0 0
429 280 279 0 0
279 272 429 0 0
1814 1815 1816 0 0
1816 1050 1814 0 0
1321 1002 209 0 0
209 208 1321 0 0
397 1531 312 0 0
312 311 397 0 0
272 279 1470 0 0
1470 273 272 0 0
809 438 1813 0 0
1813 810 809 0 0
1817 264 267 0 0
267 1818 1817 0 0
440 1819 1820 0 0
1820 441 440 0 0
1821 1822 1823 0 0
1823 1824 1821 0 0
1219 1825 1826 0 0
1826 1220 1219 0 0
860 88 96 0 0
1827 978 62 0 0
257 237 236 0 0
236 258 257 0 0
1828 1829 1830 0 0
1830 1831 1828 0 0
1832 1646 1778 0 0
1778 1750 1832 0 0
1833 1834 1835 0 0
1835 1836 1833 0 0
1837 1838 1839 0 0
922 921 1840 0 0
148 1086 1088 0 0
1088 1510 148 0 0
106 105 854 0 0
854 342 106 0 0
1241 394 1841 0 0
1841 1141 1241 0 0
1360 1842 1843 0 0
1843 1361 1360 0 0
1844 1845 1846 0 0
1846 1263 1844 0 0
1105 1545 193 0 0
193 192 1105 0 0
1308 1847 1848 0 0
1848 1216 1308 0 0
1445 1849 1850 0 0
1850 1446 1445 0 0
650 652 602 0 0
602 604 650 0 0
51 1408 1851 0 0
1851 48 51 0 0
561 1018 1852 0 0
1852 1853 561 0 0
1790 1854 1855 0 0
1855 1678 1790 0 0
1856 1857 270 0 0
270 269 1856 0 0
1379 1858 1859 0 0
1859 1380 1379 0 0
450 449 1860 0 0
1861 979 978 0 0
978 1827 1861 0 0
48 1851 1862 0 0
1862 101 48 0 0
1863 1864 894 0 0
894 893 1863 0 0
1865 1377 1380 0 0
1380 1866 1865 0 0
1867 942 307 0 0
307 1868 1867 0 0
1815 309 381 0 0
381 1816 1815 0 0
1869 1870 1728 0 0
1728 453 1869 0 0
1871 587 590 0 0
590 1872 1871 0 0
1873 1874 1875 0 0
1875 562 1873 0 0
839 1082 1876 0 0
1877 1878 385 0 0
385 384 1877 0 0
1879 658 1680 0 0
1680 1395 1879 0 0
1880 1881 1554 0 0
1554 260 1880 0 0
1882 1883 1884 0 0
1884 651 1882 0 0
1885 1886 1887 0 0
1887 1888 1885 0 0
1640 1889 1890 0 0
1890 1641 1640 0 0
1891 1892 1893 0 0
1893 1894 1891 0 0
1895 1827 62 0 0
62 337 1895 0 0
8 7 1783 0 0
1783 1610 8 0 0
544 1896 1015 0 0
1015 1014 544 0 0
1897 1898 1899 0 0
1899 1900 1897 0 0
1883 1901 657 0 0
657 656 1883 0 0
636 698 700 0 0
700 701 636 0 0
1902 1348 1347 0 0
1347 1903 1902 0 0
1432 1904 1905 0 0
1905 1433 1432 0 0
1746 947 999 0 0
999 998 1746 0 0
166 249 944 0 0
944 167 166 0 0
1906 1907 1908 0 0
1908 1909 1906 0 0
976 1910 1911 0 0
1911 1674 976 0 0
1912 935 934 0 0
934 1786 1912 0 0
1155 1156 1136 0 0
1781 1913 1643 0 0
1643 1914 1781 0 0
1593 230 1796 0 0
1796 1915 1593 0 0
974 1916 229 0 0
229 228 974 0 0
1917 1918 1749 0 0
1749 1748 1917 0 0
1919 1043 1044 0 0
1044 1920 1919 0 0
1842 1921 1922 0 0
1922 1843 1842 0 0
1923 1402 1924 0 0
1925 1926 1923 0 0
1927 1928 1929 0 0
1929 1930 1927 0 0
720 1931 1932 0 0
1932 718 720 0 0
1933 1934 1405 0 0
1405 1404 1933 0 0
1073 1529 1104 0 0
1263 1846 1935 0 0
1935 1652 1263 0 0
1555 1895 337 0 0
337 336 1555 0 0
1936 1937 1938 0 0
1938 1939 1936 0 0
1940 1229 1310 0 0
1310 1941 1940 0 0
366 1116 1586 0 0
1586 367 366 0 0
71 1942 1943 0 0
22 1856 269 0 0
612 477 1007 0 0
1944 1757 612 0 0
1945 1946 1947 0 0
1947 1948 1945 0 0
1949 1950 1951 0 0
1951 1952 1949 0 0
1953 183 1954 0 0
1954 1623 1953 0 0
1600 1955 1956 0 0
1956 1957 1600 0 0
1639 1642 1958 0 0
1958 1959 1639 0 0
1960 1961 1962 0 0
1962 1963 1960 0 0
46 1128 1881 0 0
1881 47 46 0 0
1964 1965 1852 0 0
1852 1966 1964 0 0
151 1967 1968 0 0
1968 1969 151 0 0
73 72 1970 0 0
464 1971 1972 0 0
1972 1794 464 0 0
1599 1973 1955 0 0
1955 1600 1599 0 0
868 867 1974 0 0
1974 1975 868 0 0
1825 1976 1977 0 0
1977 1826 1825 0 0
736 1650 1978 0 0
1978 1979 736 0 0
1402 1401 1446 0 0
1446 1924 1402 0 0
1980 1981 1982 0 0
1982 1983 1980 0 0
1984 1985 1855 0 0
1855 1854 1984 0 0
1986 1362 388 0 0
388 387 1986 0 0
1987 1988 423 0 0
423 1989 1987 0 0
352 590 589 0 0
589 353 352 0 0
960 959 863 0 0
863 355 960 0 0
1990 1991 1461 0 0
1461 1464 1990 0 0
1592 1593 950 0 0
950 1698 1592 0 0
91 1992 1654 0 0
1654 92 91 0 0
1993 657 1901 0 0
1901 1994 1993 0 0
1309 1308 1216 0 0
1216 1039 1309 0 0
1995 1996 1997 0 0
1997 1998 1995 0 0
1999 2000 1057 0 0
1057 2001 1999 0 0
2002 2003 2004 0 0
2004 1898 2002 0 0
2005 1042 770 0 0
770 2006 2005 0 0
424 1991 1990 0 0
1990 425 424 0 0
1918 2007 2008 0 0
2008 1533 1918 0 0
2009 2010 2011 0 0
2011 2012 2009 0 0
132 382 1530 0 0
1530 133 132 0 0
175 1537 1323 0 0
1323 1322 175 0 0
1307 1309 655 0 0
655 2013 1307 0 0
2014 2015 2016 0 0
2016 2017 2014 0 0
431 1906 1909 0 0
1909 430 431 0 0
2018 2019 2020 0 0
2020 2021 2018 0 0
1281 2022 2023 0 0
2023 1278 1281 0 0
1743 2024 2025 0 0
2025 2026 1743 0 0
130 129 1562 0 0
656 655 1038 0 0
1038 2027 656 0 0
412 432 2028 0 0
2028 1633 412 0 0
1302 1301 2029 0 0
2029 2030 1302 0 0
2031 1970 72 0 0
72 2032 2031 0 0
1438 2033 2034 0 0
2034 1439 1438 0 0
632 650 604 0 0
604 605 632 0 0
1992 2035 1655 0 0
1655 1654 1992 0 0
322 325 328 0 0
328 323 322 0 0
1204 2036 2037 0 0
2037 1829 1204 0 0
1726 1416 2038 0 0
2038 2039 1726 0 0
71 1683 1942 0 0
481 1314 1315 0 0
1315 479 481 0 0
1657 1656 1722 0 0
1722 1694 1657 0 0
2040 2041 2042 0 0
2042 964 2040 0 0
2043 1752 1700 0 0
1700 1699 2043 0 0
380 2044 1816 0 0
1816 381 380 0 0
537 1744 1743 0 0
1743 2026 537 0 0
121 2045 1596 0 0
1596 1055 121 0 0
1884 2027 579 0 0
579 654 1884 0 0
1870 2045 1424 0 0
1424 1728 1870 0 0
2046 2047 2048 0 0
2048 2049 2046 0 0
784 785 1976 0 0
1976 1825 784 0 0
2050 2051 2052 0 0
2052 2053 2050 0 0
1941 1310 69 0 0
69 1857 1941 0 0
2054 2055 2056 0 0
2056 2057 2054 0 0
400 1527 2058 0 0
2058 401 400 0 0
1768 2059 1513 0 0
1513 1512 1768 0 0
2060 2014 2017 0 0
2017 2061 2060 0 0
2062 2063 2064 0 0
2064 2065 2062 0 0
1419 2066 2067 0 0
135 70 1231 0 0
1231 136 135 0 0
1073 118 1529 0 0
2068 1351 1354 0 0
1354 373 2068 0 0
2069 2070 2071 0 0
2071 2072 2069 0 0
991 1756 1324 0 0
1324 1323 991 0 0
1091 1090 2073 0 0
2074 2075 2076 0 0
2076 2077 2074 0 0
1977 66 65 0 0
65 1730 1977 0 0
1824 1823 105 0 0
105 104 1824 0 0
1966 1852 1018 0 0
1018 1282 1966 0 0
851 1065 1067 0 0
1067 852 851 0 0
2078 2079 2080 0 0
2080 2081 2078 0 0
1965 1964 2082 0 0
2082 1279 1965 0 0
524 523 532 0 0
532 520 524 0 0
768 2083 1821 0 0
1821 764 768 0 0
2084 932 931 0 0
931 2085 2084 0 0
162 161 1469 0 0
1469 2086 162 0 0
1698 950 953 0 0
953 1068 1698 0 0
1860 2087 1316 0 0
1594 181 1009 0 0
1009 1008 1594 0 0
635 1532 2088 0 0
2088 634 635 0 0
520 532 534 0 0
534 149 520 0 0
1689 2089 2090 0 0
2090 1690 1689 0 0
2091 359 35 0 0
720 719 715 0 0
715 717 720 0 0
2092 2093 2094 0 0
2094 2095 2092 0 0
1756 2096 1672 0 0
1672 1324 1756 0 0
1310 70 69 0 0
2097 78 77 0 0
77 1022 2097 0 0
2098 2099 129 0 0
129 128 2098 0 0
494 2100 2101 0 0
2101 2102 494 0 0
447 450 444 0 0
230 229 1797 0 0
1797 1796 230 0 0
2103 1577 1578 0 0
1578 2104 2103 0 0
2001 1057 386 0 0
386 2105 2001 0 0
1154 454 453 0 0
453 1728 1154 0 0
2106 1919 1920 0 0
1920 2107 2106 0 0
2108 2109 2110 0 0
2110 2111 614 0 0
2112 2113 2114 0 0
2115 1010 1013 0 0
1013 2116 2115 0 0
988 987 2117 0 0
2117 1916 988 0 0
2118 1414 1413 0 0
1413 1140 2118 0 0
778 779 1219 0 0
1219 1218 778 0 0
1609 1608 1676 0 0
1923 2119 2120 0 0
2120 2121 1923 0 0
2122 2123 2124 0 0
2125 2126 2122 0 0
2127 1587 1291 0 0
1291 1271 2127 0 0
206 27 26 0 0
26 207 206 0 0
1923 2121 1399 0 0
1399 1402 1923 0 0
2128 2129 1950 0 0
1950 1949 2128 0 0
133 1530 197 0 0
197 196 133 0 0
1849 1765 2130 0 0
2130 2131 1849 0 0
1885 2132 1875 0 0
1875 1874 1885 0 0
2133 2134 58 0 0
58 1833 2133 0 0
142 141 271 0 0
271 2135 142 0 0
2136 2002 1898 0 0
1898 1897 2136 0 0
1775 1747 1746 0 0
1746 998 1775 0 0
5 8 1612 0 0
1612 2137 5 0 0
1812 1811 2138 0 0
2138 1913 1812 0 0
1278 2023 2139 0 0
2139 2140 1278 0 0
2141 1658 1659 0 0
2142 2143 2128 0 0
2128 2144 2142 0 0
1055 1198 250 0 0
250 1056 1055 0 0
1583 145 1727 0 0
1727 1726 1583 0 0
2145 2146 2147 0 0
2147 2148 2145 0 0
2149 2036 1471 0 0
1471 2150 2149 0 0
83 86 1870 0 0
1870 1869 83 0 0
1059 2151 2152 0 0
2152 856 1059 0 0
1675 1493 1492 0 0
2153 2154 2155 0 0
2155 2156 2153 0 0
2157 1929 1505 0 0
1505 2158 2157 0 0
3 2159 1194 0 0
1194 457 3 0 0
811 1698 1068 0 0
1068 949 811 0 0
1473 2160 2161 0 0
2161 1474 1473 0 0
174 999 1537 0 0
1537 175 174 0 0
363 1353 1352 0 0
1352 364 363 0 0
1447 1450 1214 0 0
1214 1213 1447 0 0
2162 2163 2164 0 0
2164 2165 2162 0 0
2166 2167 2168 0 0
2168 2169 2166 0 0
203 202 6 0 0
6 5 203 0 0
339 189 261 0 0
261 336 339 0 0
802 804 791 0 0
791 790 802 0 0
1412 1357 1328 0 0
1328 521 1412 0 0
1930 1929 2157 0 0
2157 2170 1930 0 0
2044 1051 1050 0 0
1050 1816 2044 0 0
1969 1968 1845 0 0
1845 1844 1969 0 0
310 1415 1589 0 0
1589 311 310 0 0
723 722 724 0 0
724 726 723 0 0
2171 2018 2021 0 0
2021 2172 2171 0 0
2173 2174 2175 0 0
2175 2176 2173 0 0
1416 1415 310 0 0
310 2038 1416 0 0
253 2177 2178 0 0
2179 254 253 0 0
1881 423 422 0 0
422 1554 1881 0 0
2180 2181 2182 0 0
2182 2183 2180 0 0
1138 1137 1178 0 0
1178 1171 1138 0 0
2184 2185 1376 0 0
1376 648 2184 0 0
2186 2187 2188 0 0
2188 763 2186 0 0
2189 2190 1346 0 0
1346 1345 2189 0 0
2191 2192 2193 0 0
2193 2194 2191 0 0
209 1003 606 0 0
606 206 209 0 0
195 344 774 0 0
422 2195 1555 0 0
1555 1554 422 0 0
875 2196 2197 0 0
478 477 652 0 0
652 651 478 0 0
515 2150 1471 0 0
1471 513 515 0 0
630 629 1200 0 0
1200 635 630 0 0
1781 1914 1535 0 0
1535 1782 1781 0 0
2198 107 23 0 0
23 22 1707 0 0
2199 2200 2201 0 0
2201 2202 2199 0 0
396 395 2044 0 0
2044 380 396 0 0
2195 2203 1895 0 0
1895 1555 2195 0 0
1928 1506 1505 0 0
1505 1929 1928 0 0
2204 2205 2206 0 0
2206 2207 2204 0 0
1631 393 405 0 0
405 1632 1631 0 0
1521 1708 141 0 0
141 140 1521 0 0
390 389 2208 0 0
2208 2089 390 0 0
286 2209 990 0 0
990 945 286 0 0
2210 2211 2212 0 0
2212 2213 2210 0 0
964 37 36 0 0
36 965 964 0 0
511 510 1113 0 0
645 883 2214 0 0
2214 2215 645 0 0
420 419 2216 0 0
1877 2217 2218 0 0
2218 1878 1877 0 0
2219 2220 1602 0 0
1602 1605 2219 0 0
111 110 1268 0 0
1268 1267 111 0 0
2221 616 610 0 0
610 2222 2221 0 0
1913 2138 1644 0 0
1644 1643 1913 0 0
421 400 399 0 0
399 418 421 0 0
2223 781 786 0 0
786 2224 2223 0 0
2022 2225 575 0 0
575 574 2022 0 0
86 1596 2045 0 0
2045 1870 86 0 0
1774 1798 1747 0 0
1747 1775 1774 0 0
2205 2226 2227 0 0
2227 2206 2205 0 0
2228 2229 1335 0 0
1335 1334 2228 0 0
2093 1270 2230 0 0
2230 2094 2093 0 0
1631 1841 394 0 0
394 393 1631 0 0
935 525 524 0 0
524 936 935 0 0
2231 2232 2233 0 0
2233 2234 2231 0 0
134 133 196 0 0
196 1052 134 0 0
2235 2236 2237 0 0
2237 1921 2235 0 0
1724 542 541 0 0
541 2238 1724 0 0
959 2216 1872 0 0
1872 863 959 0 0
1398 2127 2093 0 0
2093 2092 1398 0 0
1460 1373 1372 0 0
1372 2239 1460 0 0
2240 2241 118 0 0
118 117 2240 0 0
938 937 2242 0 0
2242 2243 938 0 0
1292 1615 1952 0 0
1952 1293 1292 0 0
1508 1468 1467 0 0
1467 1509 1508 0 0
2230 1270 1269 0 0
1269 2244 2230 0 0
746 47 1880 0 0
1880 747 746 0 0
2245 2246 2247 0 0
2248 2249 2245 0 0
2250 9 12 0 0
12 2251 2250 0 0
1776 1775 998 0 0
998 997 1776 0 0
2252 2253 2254 0 0
2254 2255 2252 0 0
2117 2256 1798 0 0
1798 1797 2117 0 0
1755 39 2096 0 0
2096 1756 1755 0 0
382 312 1531 0 0
1531 1530 382 0 0
2232 377 2257 0 0
2257 2233 2232 0 0
949 1068 1040 0 0
1040 2258 949 0 0
1907 1906 2259 0 0
2259 1866 1907 0 0
2055 2250 2251 0 0
2251 2056 2055 0 0
183 173 176 0 0
176 1954 183 0 0
2260 2261 2262 0 0
2262 1957 2260 0 0
1730 65 854 0 0
854 1731 1730 0 0
1766 1765 1849 0 0
1849 1445 1766 0 0
61 1493 448 0 0
2263 1910 2264 0 0
2264 2265 1130 0 0
1860 2266 2087 0 0
2267 2268 1613 0 0
1613 2269 2267 0 0
1423 1411 1356 0 0
1356 1355 1423 0 0
2270 2260 1957 0 0
1957 1956 2270 0 0
2271 2272 1830 0 0
1830 2273 2271 0 0
1822 1732 1731 0 0
1731 1823 1822 0 0
2274 274 277 0 0
277 2275 2274 0 0
2276 1647 659 0 0
659 2277 2276 0 0
536 1663 1744 0 0
1744 537 536 0 0
2278 1012 1011 0 0
1011 2279 2278 0 0
796 795 2280 0 0
2280 2281 796 0 0
1479 1478 1820 0 0
1820 1819 1479 0 0
1660 1661 1979 0 0
1979 1978 1660 0 0
2282 1699 1702 0 0
1702 1810 2282 0 0
1950 1770 2283 0 0
2283 1951 1950 0 0
2284 1095 2285 0 0
2285 2286 2284 0 0
1663 1665 2238 0 0
2238 541 1663 0 0
1576 1575 1607 0 0
1607 1178 1576 0 0
102 101 459 0 0
459 461 102 0 0
1251 1250 2287 0 0
2287 1630 1251 0 0
2288 2289 2079 0 0
2079 2078 2288 0 0
450 1860 1316 0 0
1129 1911 2290 0 0
2290 1130 1129 0 0
234 233 2291 0 0
2291 2292 234 0 0
2022 1281 2293 0 0
2293 2225 2022 0 0
550 549 2294 0 0
2294 2295 550 0 0
2296 2282 1810 0 0
1810 1800 2296 0 0
1994 2297 2244 0 0
2244 1993 1994 0 0
250 166 1056 0 0
2298 278 281 0 0
281 1805 2298 0 0
2299 2300 327 0 0
327 326 2299 0 0
1623 1954 1545 0 0
1545 1105 1623 0 0
2301 967 966 0 0
2302 2303 2304 0 0
2305 1650 1649 0 0
1649 2306 2305 0 0
429 248 2307 0 0
2307 2308 429 0 0
2036 2149 2309 0 0
2309 2037 2036 0 0
2310 2311 2312 0 0
353 862 2313 0 0
2006 770 772 0 0
772 2314 2006 0 0
2315 1391 170 0 0
170 169 2315 0 0
2316 2317 2318 0 0
2318 2319 2316 0 0
484 2320 2321 0 0
2321 482 484 0 0
2045 121 120 0 0
120 1424 2045 0 0
2322 2323 2185 0 0
2185 2324 2322 0 0
306 452 2325 0 0
570 569 1697 0 0
1697 1696 570 0 0
37 2042 103 0 0
103 38 37 0 0
2326 2327 2328 0 0
2328 2329 2326 0 0
2330 2331 2236 0 0
2236 2235 2330 0 0
2332 1760 1759 0 0
1759 2333 2332 0 0
248 247 2334 0 0
2334 2307 248 0 0
2335 135 138 0 0
138 1904 2335 0 0
116 2336 409 0 0
409 117 116 0 0
2019 2337 2338 0 0
2338 2020 2019 0 0
2339 2340 2220 0 0
2220 2219 2339 0 0
39 38 992 0 0
992 2096 39 0 0
686 688 1342 0 0
1342 1341 686 0 0
2341 563 562 0 0
562 1875 2341 0 0
2342 1162 1161 0 0
1662 548 1809 0 0
2343 2344 833 0 0
833 832 2343 0 0
2345 2346 925 0 0
925 924 2345 0 0
655 657 1993 0 0
1993 2013 655 0 0
178 318 224 0 0
224 179 178 0 0
427 738 740 0 0
740 711 427 0 0
2347 2252 2255 0 0
2255 2348 2347 0 0
2264 298 297 0 0
297 2349 2264 0 0
1307 2013 1269 0 0
1269 1271 1307 0 0
1719 413 1634 0 0
1634 1720 1719 0 0
1484 2350 2351 0 0
2351 1485 1484 0 0
2352 2353 2354 0 0
2354 2355 2352 0 0
493 1234 2100 0 0
2100 494 493 0 0
2356 2357 2358 0 0
2358 2359 2356 0 0
1990 2360 2361 0 0
2361 300 1990 0 0
378 2362 2363 0 0
1129 302 378 0 0
2364 114 2365 0 0
2365 2366 2364 0 0
2367 2245 2249 0 0
2249 2368 2367 0 0
2112 171 170 0 0
170 1390 2112 0 0
152 2369 2370 0 0
2370 2371 152 0 0
2372 2373 2374 0 0
2374 2375 2372 0 0
947 946 1537 0 0
1537 999 947 0 0
2376 2377 2378 0 0
2378 2379 2376 0 0
2380 2381 2382 0 0
2382 2383 2380 0 0
1487 1486 2384 0 0
2384 2385 1487 0 0
2065 2064 2386 0 0
2386 2387 2065 0 0
1452 1472 1475 0 0
1475 1453 1452 0 0
2359 2358 2388 0 0
2388 2389 2359 0 0
2156 2155 2357 0 0
2357 2356 2156 0 0
762 2390 2391 0 0
2391 2392 762 0 0
2393 2394 2395 0 0
2395 2396 2393 0 0
2043 1336 1340 0 0
1340 593 2043 0 0
294 459 403 0 0
403 295 294 0 0
2397 2398 2394 0 0
2394 2393 2397 0 0
2038 310 309 0 0
309 1815 2038 0 0
2399 2400 1517 0 0
1517 1516 2399 0 0
2396 2395 2401 0 0
2401 2402 2396 0 0
2403 2404 2405 0 0
2405 2406 2403 0 0
634 2088 2407 0 0
2407 633 634 0 0
2408 2409 2410 0 0
2410 2411 2408 0 0
2412 2413 2063 0 0
2063 2062 2412 0 0
2414 2415 2416 0 0
2416 2417 2414 0 0
2325 2418 2419 0 0
2402 2401 2154 0 0
2154 2153 2402 0 0
2420 1451 1454 0 0
1454 2421 2420 0 0
2422 2423 2424 0 0
2424 2425 2422 0 0
2426 2427 2428 0 0
2428 2429 2426 0 0
2430 2379 2378 0 0
2378 2431 2430 0 0
2432 1490 1489 0 0
2406 2405 2433 0 0
2433 2434 2406 0 0
1829 1828 1205 0 0
1205 1204 1829 0 0
566 1471 2036 0 0
2036 1204 566 0 0
2423 2422 2398 0 0
2398 2397 2423 0 0
2435 1616 1588 0 0
1588 1443 2435 0 0
1055 1596 1000 0 0
1000 1198 1055 0 0
1039 1038 655 0 0
655 1309 1039 0 0
2436 2437 2438 0 0
2438 2439 2436 0 0
2213 2212 2413 0 0
2413 2412 2213 0 0
2434 2433 2163 0 0
2163 2162 2434 0 0
315 314 404 0 0
404 1332 315 0 0
1985 2012 2440 0 0
2440 1855 1985 0 0
2441 2442 2443 0 0
2443 2444 2441 0 0
2130 2445 2059 0 0
2059 1768 2130 0 0
2446 2441 2444 0 0
2444 2447 2446 0 0
273 1589 1415 0 0
1415 123 273 0 0
2131 2130 1768 0 0
1768 1767 2131 0 0
2448 2420 2421 0 0
2421 2449 2448 0 0
2450 2451 306 0 0
306 2325 2419 0 0
2452 2453 2454 0 0
2454 2455 2452 0 0
563 2341 2456 0 0
2456 1019 563 0 0
1928 1927 576 0 0
576 575 1928 0 0
94 2457 2132 0 0
2132 584 94 0 0
2228 1836 2458 0 0
2458 2229 2228 0 0
2046 2459 2460 0 0
2460 2047 2046 0 0
2414 2461 2462 0 0
2462 2415 2414 0 0
2463 2464 1539 0 0
1539 1538 2463 0 0
1294 1293 1847 0 0
1847 1308 1294 0 0
1519 1518 2211 0 0
2211 2210 1519 0 0
2352 2355 2404 0 0
2404 2403 2352 0 0
2465 2115 2116 0 0
2116 2466 2465 0 0
2165 2164 2381 0 0
2381 2380 2165 0 0
2467 2468 2464 0 0
2464 2463 2467 0 0
2375 2374 2377 0 0
2377 2376 2375 0 0
2109 617 611 0 0
611 2110 2109 0 0
2353 2389 2388 0 0
2388 2354 2353 0 0
2469 2470 2471 0 0
2471 2472 2469 0 0
313 1318 319 0 0
319 318 313 0 0
2417 2416 2373 0 0
2373 2372 2417 0 0
1106 1084 774 0 0
1916 2117 1797 0 0
1797 229 1916 0 0
762 758 1456 0 0
1456 2390 762 0 0
1264 1263 1652 0 0
1652 1651 1264 0 0
2392 2391 2400 0 0
2400 2399 2392 0 0
978 977 2473 0 0
2309 2149 1751 0 0
1751 1779 2309 0 0
1133 2361 334 0 0
334 333 1133 0 0
1203 1202 2474 0 0
2474 2475 1203 0 0
1532 1203 2475 0 0
2475 2476 1532 0 0
2004 2271 2273 0 0
2273 2477 2004 0 0
2003 2478 2271 0 0
2271 2004 2003 0 0
1642 1641 2479 0 0
2479 2480 1642 0 0
585 1512 1515 0 0
1515 586 585 0 0
2481 301 304 0 0
304 2482 2481 0 0
2483 1666 332 0 0
332 434 2483 0 0
289 292 780 0 0
780 2484 289 0 0
1228 1153 2485 0 0
243 2486 2487 0 0
2487 244 243 0 0
935 1912 1664 0 0
1664 525 935 0 0
1894 1897 1900 0 0
1900 1645 1894 0 0
2488 2489 558 0 0
558 557 2488 0 0
1866 2259 2490 0 0
2490 1865 1866 0 0
2224 2142 2144 0 0
2144 2268 2224 0 0
1893 2136 1897 0 0
1897 1894 1893 0 0
587 1871 2491 0 0
2491 980 587 0 0
2088 1532 2476 0 0
2476 2297 2088 0 0
2492 683 685 0 0
689 2493 2492 0 0
2229 2494 1789 0 0
1789 1335 2229 0 0
2495 2496 2497 0 0
2497 2498 2495 0 0
1567 1570 2499 0 0
2499 1725 1567 0 0
2500 2501 571 0 0
2502 2503 2504 0 0
571 2505 2500 0 0
373 1354 2506 0 0
2506 374 373 0 0
1701 2507 2508 0 0
2508 2509 1701 0 0
1900 1778 1646 0 0
1646 1645 1900 0 0
982 985 376 0 0
376 375 982 0 0
138 137 331 0 0
331 2510 138 0 0
2511 2512 2513 0 0
2513 2514 2511 0 0
2515 2407 1994 0 0
1994 1901 2515 0 0
1850 1849 2131 0 0
2131 1887 1850 0 0
1700 1754 2507 0 0
2507 1701 1700 0 0
319 2516 1431 0 0
1431 320 319 0 0
189 339 1745 0 0
1745 190 189 0 0
1503 1502 2517 0 0
2517 2518 1503 0 0
2500 2505 1177 0 0
1177 1606 2500 0 0
1680 1679 1396 0 0
1396 1395 1680 0 0
181 183 1953 0 0
1953 1009 181 0 0
2140 1965 1279 0 0
1279 1278 2140 0 0
2519 2520 1958 0 0
1958 2521 2519 0 0
658 660 767 0 0
767 1680 658 0 0
2294 737 736 0 0
736 1979 2294 0 0
2522 2523 2524 0 0
242 241 2300 0 0
2300 2299 242 0 0
2320 1763 1766 0 0
1766 2321 2320 0 0
53 2525 2526 0 0
2526 54 53 0 0
2527 2054 2057 0 0
2057 1257 1256 0 0
2528 1917 515 0 0
515 1564 2528 0 0
930 2529 2530 0 0
2530 2531 930 0 0
2532 2533 2526 0 0
2526 2525 2532 0 0
2221 2222 2485 0 0
2485 2534 2221 0 0
1702 1701 2509 0 0
2509 1811 1702 0 0
144 143 247 0 0
247 125 144 0 0
2535 2536 2537 0 0
2537 2538 2535 0 0
391 1673 340 0 0
340 392 391 0 0
2539 29 59 0 0
2540 2541 2539 0 0
1536 1535 1914 0 0
1914 1832 1536 0 0
2542 2520 852 0 0
852 2543 2542 0 0
345 392 63 0 0
63 346 345 0 0
94 93 2544 0 0
2544 2457 94 0 0
2545 2546 2103 0 0
2103 2104 2545 0 0
1181 529 528 0 0
528 1179 1181 0 0
1939 1938 1585 0 0
1585 2547 1939 0 0
2548 2481 2482 0 0
2482 2549 2548 0 0
2132 2457 2341 0 0
2341 1875 2132 0 0
435 438 809 0 0
809 2284 435 0 0
2478 2550 2272 0 0
2272 2271 2478 0 0
1979 1661 2295 0 0
2295 2294 1979 0 0
987 948 2256 0 0
2256 2117 987 0 0
2286 2285 2551 0 0
2551 2552 2286 0 0
193 1547 391 0 0
391 194 193 0 0
2509 2508 2553 0 0
2553 2554 2509 0 0
1777 814 78 0 0
78 2097 1777 0 0
1288 1668 1671 0 0
1671 1370 1288 0 0
404 314 178 0 0
178 177 404 0 0
1886 2555 1850 0 0
1850 1887 1886 0 0
68 270 1857 0 0
1857 69 68 0 0
2556 1912 1786 0 0
1786 1534 2556 0 0
1934 1933 2557 0 0
2557 1687 1934 0 0
1678 1855 2440 0 0
2440 1679 1678 0 0
2119 1599 1598 0 0
1598 2120 2119 0 0
147 146 958 0 0
958 957 147 0 0
2321 1766 1445 0 0
1445 1444 2321 0 0
1954 176 1546 0 0
1546 1545 1954 0 0
1917 1748 2150 0 0
2150 515 1917 0 0
2242 1224 1223 0 0
1223 2243 2242 0 0
2558 973 975 0 0
975 437 2558 0 0
1859 1858 2559 0 0
2559 2560 1859 0 0
1401 1400 2561 0 0
2561 1444 1401 0 0
936 519 507 0 0
507 933 936 0 0
29 2539 2221 0 0
2221 2534 29 0 0
1889 2098 128 0 0
128 1890 1889 0 0
2292 2291 2562 0 0
2562 2563 2292 0 0
543 1020 1896 0 0
1896 544 543 0 0
1974 867 872 0 0
872 2564 358 0 0
2223 2224 2268 0 0
2268 2267 2223 0 0
769 1217 2083 0 0
2083 768 769 0 0
2285 2484 2565 0 0
2565 2551 2285 0 0
1147 1145 1144 0 0
1144 2566 1147 0 0
2567 1773 1776 0 0
1776 1595 2567 0 0
2457 2544 2456 0 0
2456 2341 2457 0 0
451 1609 452 0 0
2494 2558 437 0 0
437 436 2494 0 0
2568 2569 2570 0 0
2570 2571 2568 0 0
1786 934 1384 0 0
1384 1782 1786 0 0
2313 862 2572 0 0
2572 2573 2313 0 0
2385 2384 2425 0 0
2425 2424 2385 0 0
1812 1780 1800 0 0
1800 1810 1812 0 0
2546 2545 2574 0 0
2574 2575 2546 0 0
2576 2577 2578 0 0
1414 2579 2580 0 0
1333 2581 2582 0 0
2582 1332 1333 0 0
1337 1336 2282 0 0
2282 2296 1337 0 0
451 1367 1608 0 0
1685 1684 2583 0 0
2583 1873 1685 0 0
1349 2584 2585 0 0
2585 1350 1349 0 0
1201 619 618 0 0
618 614 1201 0 0
2160 2469 2472 0 0
2472 2161 2160 0 0
1133 297 300 0 0
300 2361 1133 0 0
2143 1253 2129 0 0
2129 2128 2143 0 0
1814 1050 191 0 0
191 190 1814 0 0
2186 763 2040 0 0
2586 2587 2186 0 0
1915 1796 1774 0 0
1774 1773 1915 0 0
2042 2041 104 0 0
104 103 2042 0 0
1769 2588 2497 0 0
2497 2496 1769 0 0
1317 2589 444 0 0
444 450 1317 0 0
262 2535 2538 0 0
2538 263 262 0 0
1073 1104 1103 0 0
2590 36 39 0 0
39 1755 2590 0 0
2350 2430 2431 0 0
2431 2351 2350 0 0
2591 62 61 0 0
2592 2593 2583 0 0
2583 558 2592 0 0
1259 1258 2594 0 0
2594 2595 1259 0 0
647 884 883 0 0
883 645 647 0 0
2081 2080 1428 0 0
1428 1427 2081 0 0
1337 2596 1330 0 0
1330 1338 1337 0 0
2499 2306 1649 0 0
1649 1725 2499 0 0
2346 2345 2597 0 0
2597 2598 2346 0 0
1154 1426 57 0 0
57 56 1154 0 0
2599 2600 2030 0 0
2030 2029 2599 0 0
501 1005 518 0 0
518 517 501 0 0
492 494 2102 0 0
2102 2601 492 0 0
1102 1101 1480 0 0
2475 2474 2095 0 0
2095 2094 2475 0 0
785 788 1483 0 0
1483 1976 785 0 0
1221 1220 2588 0 0
2588 1769 1221 0 0
1410 1328 1357 0 0
1357 1356 1410 0 0
1366 2602 2603 0 0
2604 1363 1366 0 0
2023 2605 2606 0 0
2606 2139 2023 0 0
1441 1381 1382 0 0
1382 577 1441 0 0
2607 2608 2595 0 0
2595 2594 2607 0 0
2297 1994 2407 0 0
2407 2088 2297 0 0
2484 780 773 0 0
773 2565 2484 0 0
2007 1918 1917 0 0
1917 2528 2007 0 0
2605 2023 2022 0 0
2022 574 2605 0 0
2485 2222 1021 0 0
1021 1228 2485 0 0
1811 2509 2554 0 0
2554 2138 1811 0 0
2031 2032 2609 0 0
1543 1542 2610 0 0
2296 1800 1383 0 0
1383 2611 2296 0 0
658 1879 2277 0 0
2277 659 658 0 0
1614 1949 1952 0 0
1952 1615 1614 0 0
2083 2498 1822 0 0
1822 1821 2083 0 0
1874 2593 1886 0 0
1886 1885 1874 0 0
1407 1406 1298 0 0
1298 1297 1407 0 0
1253 1252 1520 0 0
1520 2129 1253 0 0
1265 2612 2613 0 0
2613 2614 1265 0 0
764 1821 1824 0 0
1824 765 764 0 0
2555 1886 2593 0 0
2593 2592 2555 0 0
2147 2446 2447 0 0
2447 2148 2147 0 0
613 1202 1201 0 0
1201 614 613 0 0
1808 1393 1809 0 0
2269 1613 1616 0 0
1616 2435 2269 0 0
2615 2072 2071 0 0
2071 2616 2615 0 0
1706 2159 107 0 0
2617 1707 1706 0 0
540 542 529 0 0
529 1392 540 0 0
979 1861 2264 0 0
2264 1910 979 0 0
2133 2228 1334 0 0
1334 1403 2133 0 0
1017 25 981 0 0
981 1143 1017 0 0
1772 2618 2619 0 0
200 203 2620 0 0
2620 2621 200 0 0
2622 2015 2623 0 0
2623 2624 2622 0 0
563 1019 1018 0 0
1018 561 563 0 0
176 175 1322 0 0
1322 1546 176 0 0
2387 2386 2468 0 0
2468 2467 2387 0 0
572 571 2501 0 0
2501 2625 572 0 0
2486 1817 1818 0 0
1818 2487 2486 0 0
2554 2553 1892 0 0
1892 1891 2554 0 0
1687 2557 559 0 0
559 1684 1687 0 0
1741 1563 1564 0 0
514 513 565 0 0
1058 1057 2000 0 0
2000 2626 1058 0 0
2203 1861 1827 0 0
1827 1895 2203 0 0
203 5 2137 0 0
2137 2620 203 0 0
1371 815 814 0 0
814 1289 1371 0 0
2627 2317 2316 0 0
2316 2628 2627 0 0
2593 1874 1873 0 0
1873 2583 2593 0 0
2629 1657 1694 0 0
1694 1697 2629 0 0
592 1752 2043 0 0
2043 593 592 0 0
1661 1392 1394 0 0
1394 2295 1661 0 0
2308 1571 280 0 0
280 429 2308 0 0
1665 1664 1912 0 0
1912 2556 1665 0 0
1887 2131 1767 0 0
1767 1888 1887 0 0
1533 2008 2556 0 0
2556 1534 1533 0 0
2616 2071 2046 0 0
2046 2049 2616 0 0
1764 2445 2130 0 0
2130 1765 1764 0 0
2086 1469 278 0 0
278 2298 2086 0 0
92 2629 1016 0 0
1016 93 92 0 0
271 141 1708 0 0
1708 268 271 0 0
2134 2541 2540 0 0
2540 58 2134 0 0
435 2284 2286 0 0
2286 1713 435 0 0
239 256 259 0 0
259 240 239 0 0
2552 2630 1985 0 0
1985 1984 2552 0 0
1716 2458 1836 0 0
1836 1835 1716 0 0
1715 703 702 0 0
702 2631 1715 0 0
933 507 2611 0 0
2611 1383 933 0 0
1686 1853 2140 0 0
2140 2139 1686 0 0
305 807 451 0 0
586 1515 1992 0 0
1992 91 586 0 0
2229 2458 2558 0 0
2558 2494 2229 0 0
2625 2632 2633 0 0
2633 572 2625 0 0
2470 2634 2635 0 0
2635 2471 2470 0 0
948 165 168 0 0
168 2256 948 0 0
2363 2636 2637 0 0
1924 2638 2489 0 0
2489 2488 1924 0 0
1536 1749 1918 0 0
1918 1533 1536 0 0
554 1762 2261 0 0
2261 2260 554 0 0
2066 2639 2067 0 0
1652 1935 1108 0 0
1108 1107 1652 0 0
2640 2135 68 0 0
68 67 2640 0 0
2314 2267 2269 0 0
2269 2010 2314 0 0
2159 3 2 0 0
2 107 2159 0 0
2641 2642 2643 0 0
2643 2644 2641 0 0
992 106 342 0 0
342 341 992 0 0
598 597 601 0 0
601 1002 598 0 0
215 321 324 0 0
324 216 215 0 0
2543 852 1067 0 0
1067 2645 2543 0 0
804 2646 2647 0 0
2647 791 804 0 0
853 852 2520 0 0
2520 2519 853 0 0
2648 2649 2569 0 0
2569 2568 2648 0 0
1136 83 1869 0 0
1869 1155 1136 0 0
93 1016 1015 0 0
1015 2544 93 0 0
2094 2230 2476 0 0
2476 2475 2094 0 0
615 2650 1648 0 0
1648 1647 615 0 0
1741 2651 877 0 0
877 876 1741 0 0
2123 2652 2653 0 0
2653 2124 2123 0 0
1898 2004 2477 0 0
2477 1899 1898 0 0
1 430 113 0 0
113 41 1 0 0
1853 1852 1965 0 0
1965 2140 1853 0 0
431 1004 2259 0 0
2259 1906 431 0 0
1202 613 2276 0 0
2276 2474 1202 0 0
2037 2309 2477 0 0
2477 2273 2037 0 0
2335 67 70 0 0
70 135 2335 0 0
1390 2113 2112 0 0
2654 2655 1998 0 0
1998 1997 2654 0 0
2317 840 839 0 0
839 1876 2317 0 0
1627 1626 1620 0 0
1620 1619 1627 0 0
447 468 2591 0 0
2591 61 447 0 0
615 614 2111 0 0
2111 2650 615 0 0
1601 1600 1957 0 0
1957 2262 1601 0 0
1541 1540 2146 0 0
2146 2145 1541 0 0
1830 2272 2656 0 0
2656 1831 1830 0 0
650 632 1882 0 0
1882 651 650 0 0
99 2657 2658 0 0
2658 100 99 0 0
594 2659 2026 0 0
2660 595 594 0 0
2661 674 2192 0 0
2192 2191 2661 0 0
2129 1520 1770 0 0
1770 1950 2129 0 0
2662 857 856 0 0
856 2152 2662 0 0
506 2596 2611 0 0
2611 507 506 0 0
1597 1594 1008 0 0
1008 1084 1597 0 0
2663 1611 1610 0 0
1610 1669 2664 0 0
57 1834 1833 0 0
1833 58 57 0 0
2238 2008 2007 0 0
2007 1724 2238 0 0
1005 501 208 0 0
208 207 1005 0 0
1327 519 521 0 0
521 1328 1327 0 0
2246 109 112 0 0
112 2247 2246 0 0
558 2583 1684 0 0
1684 559 558 0 0
1279 2082 2194 0 0
2194 2193 1279 0 0
2665 2454 2453 0 0
2453 2666 2665 0 0
1989 423 1881 0 0
1881 1128 1989 0 0
779 784 1825 0 0
1825 1219 779 0 0
1020 1019 2456 0 0
2456 1896 1020 0 0
2033 1556 1557 0 0
1557 2034 2033 0 0
2667 2668 2669 0 0
2669 2670 2667 0 0
748 1051 1799 0 0
1799 745 748 0 0
2039 1814 190 0 0
190 1745 2039 0 0
891 2214 883 0 0
883 899 891 0 0
2634 1455 760 0 0
760 2635 2634 0 0
2516 2671 1432 0 0
1432 1431 2516 0 0
2295 1394 1808 0 0
1808 550 2295 0 0
1727 144 125 0 0
125 124 1727 0 0
2672 2673 2674 0 0
2674 2675 2672 0 0
149 1412 521 0 0
521 520 149 0 0
358 2564 918 0 0
918 359 358 0 0
167 944 947 0 0
947 1746 167 0 0
290 949 2258 0 0
2258 291 290 0 0
1397 1443 1588 0 0
1588 1587 1397 0 0
2676 1681 1682 0 0
1682 2677 2676 0 0
1751 2149 2150 0 0
2150 1748 1751 0 0
1744 1663 541 0 0
541 540 1744 0 0
1394 1393 1808 0 0
2678 2679 1972 0 0
1972 1971 2678 0 0
2091 356 359 0 0
2680 2681 2682 0 0
2683 2684 2685 0 0
2686 276 275 0 0
275 2687 2686 0 0
2622 2492 2493 0 0
2493 2015 2622 0 0
981 980 1144 0 0
1144 1143 981 0 0
2429 2428 466 0 0
466 465 2429 0 0
2024 1978 1650 0 0
1650 2305 2024 0 0
810 1813 227 0 0
227 1592 810 0 0
1630 2576 1841 0 0
1841 1631 1630 0 0
2442 2448 2449 0 0
2449 2443 2442 0 0
1622 1621 1449 0 0
1449 1448 1622 0 0
2688 1838 1837 0 0
1837 2689 2688 0 0
1866 1380 1859 0 0
1859 1907 1866 0 0
425 1990 300 0 0
300 299 425 0 0
2690 1787 1788 0 0
1788 2691 2690 0 0
1815 1814 2039 0 0
2039 2038 1815 0 0
1642 2480 2521 0 0
2521 1958 1642 0 0
92 1654 1657 0 0
1657 2629 92 0 0
2692 445 444 0 0
444 2589 2692 0 0
399 402 970 0 0
970 1586 399 0 0
2012 2011 1442 0 0
1442 2440 2012 0 0
2693 2367 2368 0 0
2368 2694 2693 0 0
2695 2696 2697 0 0
2188 2187 2698 0 0
2437 52 55 0 0
55 2438 2437 0 0
2134 2699 2650 0 0
2650 2541 2134 0 0
2700 2701 1791 0 0
1791 2702 2700 0 0
2138 2554 1891 0 0
1891 1644 2138 0 0
954 1867 1868 0 0
1868 955 954 0 0
2703 385 1878 0 0
1878 2704 2703 0 0
525 1664 536 0 0
536 523 525 0 0
642 644 664 0 0
664 666 642 0 0
1101 1102 915 0 0
915 914 1101 0 0
2209 286 285 0 0
285 2701 2209 0 0
347 346 1483 0 0
1483 788 347 0 0
88 860 2705 0 0
2705 89 88 0 0
1595 1776 997 0 0
997 182 1595 0 0
2706 2707 212 0 0
212 211 2706 0 0
2458 1716 973 0 0
973 2558 2458 0 0
260 188 747 0 0
747 1880 260 0 0
2633 2632 2624 0 0
2624 2623 2633 0 0
2581 2708 1381 0 0
1381 2582 2581 0 0
968 1791 2701 0 0
2701 285 968 0 0
717 1591 1931 0 0
1931 720 717 0 0
2709 169 172 0 0
172 2347 2348 0 0
692 694 2323 0 0
2323 2322 692 0 0
572 2060 2061 0 0
2061 573 572 0 0
1336 2043 1699 0 0
1699 2282 1336 0 0
2710 2711 2712 0 0
2712 2713 2710 0 0
2671 2335 1904 0 0
1904 1432 2671 0 0
962 180 179 0 0
179 226 962 0 0
755 757 2603 0 0
2603 2602 755 0 0
2714 2715 157 0 0
157 156 2714 0 0
2563 2562 2289 0 0
2289 2288 2563 0 0
1072 2716 2717 0 0
2717 887 1072 0 0
2718 2719 2053 0 0
2053 2052 2718 0 0
2493 689 691 0 0
691 2720 2493 0 0
2721 2722 2723 0 0
2715 2612 1265 0 0
1265 157 2715 0 0
2724 871 867 0 0
867 864 2724 0 0
2096 992 341 0 0
341 1672 2096 0 0
1500 1503 2725 0 0
712 2631 702 0 0
702 713 712 0 0
1593 1915 951 0 0
951 950 1593 0 0
639 661 1725 0 0
1725 1649 639 0 0
2071 2070 2459 0 0
2459 2046 2071 0 0
2201 2200 1946 0 0
1946 1945 2201 0 0
613 615 1647 0 0
1647 2276 613 0 0
1369 1368 1574 0 0
1574 1573 1369 0 0
592 2726 1753 0 0
1753 1752 592 0 0
1506 1928 575 0 0
575 2225 1506 0 0
610 609 1021 0 0
1021 2222 610 0 0
1743 1660 1978 0 0
1978 2024 1743 0 0
578 653 654 0 0
654 579 578 0 0
2119 1923 1926 0 0
1926 2727 2119 0 0
1899 2477 2309 0 0
2309 1779 1899 0 0
208 501 503 0 0
503 1321 208 0 0
532 523 537 0 0
537 533 532 0 0
2370 1262 1261 0 0
1261 2371 2370 0 0
763 2188 768 0 0
768 764 763 0 0
1064 2684 2683 0 0
2683 1061 1064 0 0
2551 2565 1042 0 0
1042 2005 2551 0 0
2217 2728 2729 0 0
2729 2218 2217 0 0
633 2407 2515 0 0
2515 631 633 0 0
2305 2167 2166 0 0
2166 2730 2305 0 0
1685 1873 562 0 0
562 561 1685 0 0
1789 1714 1854 0 0
1854 1790 1789 0 0
1706 1521 1382 0 0
1382 1195 1706 0 0
1597 2567 1595 0 0
1595 1594 1597 0 0
765 1824 104 0 0
104 2041 765 0 0
628 579 2027 0 0
2027 1038 628 0 0
649 737 2294 0 0
2294 549 649 0 0
1106 1041 1068 0 0
1068 953 1106 0 0
1495 2731 2732 0 0
2732 1496 1495 0 0
1505 1504 2733 0 0
2733 2158 1505 0 0
1220 1826 1729 0 0
1729 2588 1220 0 0
1630 2287 2577 0 0
2577 2576 1630 0 0
2494 436 1714 0 0
1714 1789 2494 0 0
1217 2495 2498 0 0
2498 2083 1217 0 0
2560 1908 1907 0 0
1907 1859 2560 0 0
1616 1615 1292 0 0
1292 1588 1616 0 0
1293 1952 1951 0 0
1951 1847 1293 0 0
1713 1984 1854 0 0
1854 1714 1713 0 0
1848 2283 2496 0 0
2496 2495 1848 0 0
2256 168 1747 0 0
1747 1798 2256 0 0
1386 2734 2735 0 0
2735 647 1386 0 0
877 2651 2736 0 0
2736 2737 877 0 0
2738 1704 661 0 0
661 663 2738 0 0
1139 1141 1841 0 0
1841 2576 1139 0 0
2630 2009 2012 0 0
2012 1985 2630 0 0
2011 2435 1443 0 0
1443 1442 2011 0 0
1337 2296 2611 0 0
2611 2596 1337 0 0
1823 1731 854 0 0
854 105 1823 0 0
2010 2269 2435 0 0
2435 2011 2010 0 0
1885 1888 584 0 0
584 2132 1885 0 0
2025 2024 2305 0 0
2305 2730 2025 0 0
2597 2735 2734 0 0
2734 2598 2597 0 0
2739 1481 1101 0 0
1101 1100 2739 0 0
2209 2590 1755 0 0
1755 990 2209 0 0
1685 561 2740 0 0
2740 1686 1685 0 0
1807 1806 2608 0 0
2608 2607 1807 0 0
591 2741 2726 0 0
2726 592 591 0 0
1914 1643 1646 0 0
1646 1832 1914 0 0
1665 2556 2008 0 0
2008 2238 1665 0 0
249 286 945 0 0
945 944 249 0 0
2286 2552 1984 0 0
1984 1713 2286 0 0
2498 2497 1732 0 0
1732 1822 2498 0 0
1882 2515 1901 0 0
1901 1883 1882 0 0
1904 138 2510 0 0
2510 1905 1904 0 0
2630 2005 2006 0 0
2006 2009 2630 0 0
2742 293 296 0 0
296 961 2742 0 0
2253 1558 1559 0 0
1559 2254 2253 0 0
2561 482 2321 0 0
2321 1444 2561 0 0
2225 2293 1507 0 0
1507 1506 2225 0 0
1243 996 995 0 0
995 1244 1243 0 0
2528 527 1724 0 0
1724 2007 2528 0 0
951 2567 1597 0 0
1597 952 951 0 0
2009 2006 2314 0 0
2314 2010 2009 0 0
1829 2037 2273 0 0
2273 1830 1829 0 0
2552 2551 2005 0 0
2005 2630 2552 0 0
652 477 600 0 0
600 602 652 0 0
555 554 2260 0 0
2260 2270 555 0 0
2588 1729 1732 0 0
1732 2497 2588 0 0
2142 782 783 0 0
783 2143 2142 0 0
2144 2128 1949 0 0
1949 1614 2144 0 0
1826 1977 1730 0 0
1730 1729 1826 0 0
1354 1353 2743 0 0
2743 2506 1354 0 0
2539 2541 2650 0 0
2650 2111 2539 0 0
2133 1833 1836 0 0
1836 2228 2133 0 0
1719 1249 410 0 0
410 413 1719 0 0
2744 2745 2746 0 0
2746 2747 2744 0 0
468 463 1795 0 0
845 819 1549 0 0
1549 2332 845 0 0
2027 1884 1883 0 0
1883 656 2027 0 0
27 206 606 0 0
606 608 27 0 0
1179 1563 879 0 0
268 1707 22 0 0
22 269 268 0 0
629 619 1201 0 0
1201 1200 629 0 0
1770 1769 2496 0 0
2496 2283 1770 0 0
2748 2749 1712 0 0
1712 1711 2748 0 0
2703 2105 386 0 0
386 385 2703 0 0
783 776 1253 0 0
1253 2143 783 0 0
505 1319 503 0 0
503 502 505 0 0
777 778 1218 0 0
1218 1252 777 0 0
771 770 1042 0 0
1042 787 771 0 0
2750 1493 1675 0 0
1230 439 136 0 0
136 1231 1230 0 0
1693 1692 1281 0 0
1281 1280 1693 0 0
2629 1697 569 0 0
569 1016 2629 0 0
2751 2575 2574 0 0
2574 2752 2751 0 0
1586 970 1001 0 0
1001 367 1586 0 0
1749 1536 1832 0 0
1832 1750 1749 0 0
2659 533 537 0 0
537 2026 2659 0 0
2224 786 782 0 0
782 2142 2224 0 0
2244 1269 2013 0 0
2013 1993 2244 0 0
1778 1900 1899 0 0
1899 1779 1778 0 0
1241 831 745 0 0
745 1799 1241 0 0
799 1025 2753 0 0
1271 1291 1294 0 0
1294 1307 1271 0 0
1155 1869 453 0 0
453 456 1155 0 0
2565 773 775 0 0
775 1042 2565 0 0
588 24 1089 0 0
1089 589 588 0 0
2754 1118 1628 0 0
2755 616 2221 0 0
2221 2539 2755 0 0
2281 2280 2756 0 0
2756 2757 2281 0 0
766 1790 1678 0 0
1678 767 766 0 0
2133 1403 2699 0 0
2699 2134 2133 0 0
1879 2092 2095 0 0
2095 2277 1879 0 0
1679 2440 1442 0 0
1442 1396 1679 0 0
2758 2652 2759 0 0
2759 2760 2758 0 0
285 251 1199 0 0
1199 969 285 0 0
1102 2761 915 0 0
1740 648 282 0 0
282 284 1740 0 0
569 568 1014 0 0
1014 1016 569 0 0
1476 1303 1306 0 0
1306 1477 1476 0 0
951 1915 1773 0 0
1773 2567 951 0 0
2762 2702 2058 0 0
2058 1526 2762 0 0
963 2763 2040 0 0
2040 964 963 0 0
528 527 2528 0 0
2528 1564 528 0 0
2764 2693 2694 0 0
2694 2765 2764 0 0
2284 809 812 0 0
812 1095 2284 0 0
432 1052 1053 0 0
1053 2028 432 0 0
2555 1924 1446 0 0
1446 1850 2555 0 0
422 425 299 0 0
299 2195 422 0 0
1036 1035 2102 0 0
2102 2101 1036 0 0
2766 1941 1857 0 0
1857 1856 2766 0 0
1426 1425 1834 0 0
1834 57 1426 0 0
2640 1318 142 0 0
142 2135 2640 0 0
2767 1757 1944 0 0
858 1069 2768 0 0
1143 1122 2769 0 0
2769 1017 1143 0 0
2770 2513 2512 0 0
2771 2772 2770 0 0
2773 1067 1066 0 0
1066 2774 2773 0 0
2326 2329 1305 0 0
1305 1304 2326 0 0
2536 2764 2765 0 0
2765 2537 2536 0 0
2775 1076 1078 0 0
2776 1864 1863 0 0
2 1 41 0 0
41 108 2 0 0
21 2766 1856 0 0
1856 22 21 0 0
2777 2778 2779 0 0
2780 1981 2781 0 0
2601 2102 1035 0 0
2782 2783 2784 0 0
2474 2276 2277 0 0
2277 2095 2474 0 0
417 416 2679 0 0
2679 2678 417 0 0
2785 2786 2218 0 0
2218 2729 2785 0 0
2787 1409 1411 0 0
1411 1422 2787 0 0
1130 2265 303 0 0
303 302 1130 0 0
1976 1483 66 0 0
66 1977 1976 0 0
2788 2789 1890 0 0
1890 128 2788 0 0
406 134 1052 0 0
1052 432 406 0 0
1847 1951 2283 0 0
2283 1848 1847 0 0
246 245 2178 0 0
2178 2177 246 0 0
826 825 1710 0 0
1710 1709 826 0 0
1891 1894 1645 0 0
1645 1644 1891 0 0
2268 2144 1614 0 0
1614 1613 2268 0 0
1599 2119 2727 0 0
2727 1973 1599 0 0
1051 2044 395 0 0
395 1799 1051 0 0
1275 1274 2649 0 0
2649 2648 1275 0 0
1226 334 2361 0 0
2361 2360 1226 0 0
822 821 839 0 0
839 838 822 0 0
2040 763 765 0 0
765 2041 2040 0 0
31 2534 1153 0 0
1153 1152 31 0 0
2325 2790 2418 0 0
2789 2479 1641 0 0
1641 1890 2789 0 0
2791 2792 2793 0 0
2794 1705 1704 0 0
1704 2738 2794 0 0
989 1834 1425 0 0
1425 986 989 0 0
2786 2704 1878 0 0
1878 2218 2786 0 0
2230 2244 2297 0 0
2297 2476 2230 0 0
1813 975 228 0 0
228 227 1813 0 0
1265 2614 2795 0 0
2795 1266 1265 0 0
1395 1398 2092 0 0
2092 1879 1395 0 0
1528 118 2241 0 0
101 1862 403 0 0
403 459 101 0 0
1114 2796 1192 0 0
1192 1191 1114 0 0
2544 1015 1896 0 0
1896 2456 2544 0 0
895 897 2797 0 0
2644 2757 2756 0 0
2756 2641 2644 0 0
1736 1739 2798 0 0
2798 2799 1736 0 0
2800 2364 2366 0 0
2366 350 2778 0 0
2801 1703 293 0 0
293 2742 2801 0 0
127 2788 128 0 0
195 194 345 0 0
345 344 195 0 0
772 771 781 0 0
781 2223 772 0 0
1398 1397 1587 0 0
1587 2127 1398 0 0
2802 2803 2804 0 0
2804 2805 2802 0 0
520 519 936 0 0
936 524 520 0 0
2806 2656 2272 0 0
2272 2550 2806 0 0
1216 1848 2495 0 0
2495 1217 1216 0 0
95 1772 2619 0 0
1225 2807 2808 0 0
2808 1222 1225 0 0
285 969 968 0 0
2640 2671 2516 0 0
2516 1318 2640 0 0
2451 1006 306 0 0
2809 1636 1635 0 0
1635 2810 2809 0 0
2139 2606 1687 0 0
1687 1686 2139 0 0
2811 1062 2319 0 0
2319 2318 2811 0 0
2127 1271 1270 0 0
1270 2093 2127 0 0
2566 1144 980 0 0
980 2491 2566 0 0
636 638 2812 0 0
2812 698 636 0 0
875 874 2196 0 0
2639 860 861 0 0
2813 1502 1501 0 0
131 405 393 0 0
393 396 131 0 0
2814 920 2815 0 0
1375 1374 1422 0 0
1422 1421 1375 0 0
1195 1194 2159 0 0
2159 1706 1195 0 0
35 34 2091 0 0
2816 829 828 0 0
2817 2805 2804 0 0
2818 2819 2820 0 0
2820 2821 2818 0 0
1083 839 821 0 0
2822 2823 2673 0 0
2673 2672 2822 0 0
856 855 859 0 0
859 841 856 0 0
2085 1070 1071 0 0
1071 2084 2085 0 0
631 2515 1882 0 0
1882 632 631 0 0
2231 2234 2824 0 0
51 50 1792 0 0
1792 362 51 0 0
1888 1767 585 0 0
585 584 1888 0 0
1793 2743 1353 0 0
1353 363 1793 0 0
401 2058 2702 0 0
2702 1791 401 0 0
2584 316 317 0 0
317 2585 2584 0 0
1515 1514 2035 0 0
2035 1992 1515 0 0
2737 2825 878 0 0
878 877 2737 0 0
161 398 1470 0 0
1470 1469 161 0 0
881 880 2826 0 0
645 2215 2827 0 0
1673 1672 341 0 0
341 340 1673 0 0
2828 2173 2176 0 0
2176 582 2828 0 0
2829 2820 909 0 0
909 908 2829 0 0
753 2828 582 0 0
582 581 753 0 0
651 1884 654 0 0
654 478 651 0 0
1528 1529 118 0 0
1365 1364 2825 0 0
2825 2737 1365 0 0
2737 2736 2830 0 0
2830 2174 2737 0 0
1959 1958 2520 0 0
2520 2542 1959 0 0
1745 1583 1726 0 0
1726 2039 1745 0 0
2432 1489 2831 0 0
1953 1623 774 0 0
2832 2833 2819 0 0
2819 2818 2832 0 0
2716 2834 2835 0 0
2835 2717 2716 0 0
2836 1256 1259 0 0
2837 1522 2838 0 0
2700 36 2590 0 0
1717 988 1916 0 0
1916 974 1717 0 0
2114 2113 2839 0 0
1259 2595 2840 0 0
2258 1040 774 0 0
983 982 2085 0 0
931 930 983 0 0
1734 1208 2841 0 0
1987 2842 1988 0 0
2778 2777 2843 0 0
1009 1953 774 0 0
2837 1523 1522 0 0
143 2334 247 0 0
2844 1629 1118 0 0
2845 2846 1118 0 0
2708 1196 1381 0 0
1707 268 1708 0 0
2846 1120 1118 0 0
2847 2848 1118 0 0
1119 1118 1255 0 0
1237 2849 607 0 0
607 1024 1237 0 0
298 2264 1861 0 0
1861 2203 298 0 0
1318 2516 319 0 0
2762 847 2702 0 0
1004 2490 2259 0 0
959 420 2216 0 0
154 1967 151 0 0
1718 1249 1719 0 0
1872 2216 1871 0 0
863 1872 590 0 0
2850 1126 1118 0 0
1523 2851 1524 0 0
2066 2852 2639 0 0
964 2042 37 0 0
344 347 774 0 0
2751 2752 2853 0 0
2854 2855 2856 0 0
930 2531 983 0 0
953 952 1106 0 0
2840 2836 1259 0 0
292 291 774 0 0
982 1070 2085 0 0
847 36 2700 0 0
929 2529 930 0 0
1135 2349 297 0 0
470 2857 469 0 0
1419 1418 2858 0 0
848 2859 849 0 0
2860 2861 2141 0 0
2141 2861 1658 0 0
2862 1134 1133 0 0
1582 1581 2863 0 0
2639 2852 860 0 0
297 1133 1135 0 0
1133 333 2862 0 0
985 984 2864 0 0
983 2085 931 0 0
2279 2865 2278 0 0
2548 2549 2866 0 0
1653 1107 2867 0 0
1983 1982 2868 0 0
713 704 2869 0 0
2869 714 713 0 0
2778 350 2779 0 0
2870 2871 2531 0 0
2871 2872 2873 0 0
2874 2875 2876 0 0
1580 2877 2875 0 0
2531 2530 2870 0 0
2876 2870 2874 0 0
2314 772 2223 0 0
2223 2267 2314 0 0
95 87 1772 0 0
2870 2530 2874 0 0
2531 2871 2873 0 0
1658 1417 1420 0 0
2780 2878 1981 0 0
1880 47 1881 0 0
989 988 1717 0 0
1717 1835 989 0 0
1733 1735 2879 0 0
989 1835 1834 0 0
2880 2835 2834 0 0
2834 2881 2880 0 0
1835 1717 1716 0 0
2882 1254 1118 0 0
1547 1325 1673 0 0
1673 391 1547 0 0
2754 2883 1118 0 0
2135 271 270 0 0
270 68 2135 0 0
415 414 2884 0 0
1121 2885 1118 0 0
2671 2640 67 0 0
67 2335 2671 0 0
1142 2886 1118 0 0
2363 2362 2636 0 0
1632 405 406 0 0
406 411 1632 0 0
2876 2875 2877 0 0
148 147 1093 0 0
1093 1086 148 0 0
2781 1981 1980 0 0
2887 848 850 0 0
2724 864 866 0 0
866 870 2724 0 0
1211 2841 1208 0 0
333 1667 2862 0 0
666 667 2888 0 0
2888 2889 666 0 0
2766 1940 1941 0 0
1140 1413 45 0 0
144 1727 145 0 0
840 2317 2627 0 0
192 195 774 0 0
2171 2172 2890 0 0
2890 1283 2171 0 0
1127 2844 1118 0 0
1555 336 261 0 0
873 2891 874 0 0
982 375 1070 0 0
1526 2058 1527 0 0
1795 1094 1093 0 0
2892 2893 1118 0 0
291 2258 774 0 0
2883 1131 1118 0 0
350 349 2779 0 0
976 979 1910 0 0
372 2068 373 0 0
2886 2845 1118 0 0
2894 2847 1118 0 0
2895 2896 2897 0 0
2897 2898 2895 0 0
1703 2801 2899 0 0
919 1527 355 0 0
1150 1148 1118 0 0
2848 2850 1118 0 0
2885 2894 1118 0 0
1286 1285 2900 0 0
2900 2901 1286 0 0
2893 2882 1118 0 0
2315 169 2709 0 0
1207 2902 1118 0 0
1913 1781 1780 0 0
1780 1812 1913 0 0
1095 289 2484 0 0
2484 2285 1095 0 0
2903 1168 2904 0 0
2904 2905 2903 0 0
1157 1174 2906 0 0
2906 1180 1157 0 0
1138 1171 1172 0 0
1172 1185 1138 0 0
1459 2907 1374 0 0
1374 1373 1459 0 0
1173 1157 2908 0 0
2908 2909 1173 0 0
2910 2182 2181 0 0
2181 2911 2910 0 0
914 916 1436 0 0
2912 2913 1159 0 0
1159 1158 2912 0 0
2914 2915 2916 0 0
2916 2917 2914 0 0
2918 1206 1173 0 0
1173 2909 2918 0 0
2898 2897 2913 0 0
2913 2912 2898 0 0
2466 1194 1197 0 0
1197 2465 2466 0 0
2702 847 2700 0 0
2485 1153 2534 0 0
2383 2382 2462 0 0
2462 2461 2383 0 0
355 863 352 0 0
2810 2919 2809 0 0
1165 1164 1171 0 0
1171 2920 1165 0 0
2921 2922 2923 0 0
2923 2924 2921 0 0
2925 2926 2410 0 0
2410 2409 2925 0 0
2927 2928 2929 0 0
2929 2930 2927 0 0
2928 2927 2931 0 0
2931 2932 2928 0 0
2933 2903 2905 0 0
2905 2934 2933 0 0
1188 2917 2916 0 0
2916 1185 1188 0 0
2935 2936 2932 0 0
2932 2931 2935 0 0
2937 2936 2935 0 0
2935 2938 2937 0 0
606 1003 1024 0 0
1024 607 606 0 0
2926 2925 2939 0 0
2939 2940 2926 0 0
2938 2941 2942 0 0
2942 2937 2938 0 0
381 309 312 0 0
312 382 381 0 0
1158 1160 2943 0 0
2944 1161 1163 0 0
2902 2892 1118 0 0
2532 2571 2570 0 0
2570 2533 2532 0 0
1180 1163 1162 0 0
1162 2342 1180 0 0
1164 1166 2945 0 0
2946 2947 2948 0 0
2948 2949 2946 0 0
1180 2906 1163 0 0
2916 2915 1111 0 0
1111 1138 2916 0 0
1138 1185 2916 0 0
2799 2798 2190 0 0
2190 2189 2799 0 0
2950 2910 2911 0 0
2911 2951 2950 0 0
1157 1180 1179 0 0
1179 511 1157 0 0
2920 1171 1177 0 0
2952 2949 2948 0 0
2948 2953 2952 0 0
2907 2787 1422 0 0
1422 1374 2907 0 0
2954 2955 184 0 0
184 187 2954 0 0
2342 1181 1180 0 0
895 2797 892 0 0
892 2956 895 0 0
2924 2408 2411 0 0
2411 2921 2924 0 0
2957 2958 2947 0 0
2947 2946 2957 0 0
94 584 586 0 0
586 91 94 0 0
1668 1742 2664 0 0
2664 1669 1668 0 0
1182 1184 1187 0 0
1185 1182 1187 0 0
1174 1186 2906 0 0
2015 2493 2720 0 0
2959 2016 2015 0 0
2960 2950 2951 0 0
2951 2961 2960 0 0
1186 1189 2962 0 0
2195 299 298 0 0
298 2203 2195 0 0
2590 2209 2701 0 0
2701 2700 2590 0 0
1525 1524 1466 0 0
1466 1465 1525 0 0
2963 2964 2965 0 0
2966 2967 2968 0 0
2969 2970 2971 0 0
2972 2973 2974 0 0
2975 2976 2977 0 0
2978 2979 2980 0 0
2978 2981 2982 0 0
2963 2983 2964 0 0
2984 2985 2986 0 0
2981 2973 2987 0 0
2987 2988 2981 0 0
2989 2990 2991 0 0
2992 2993 2994 0 0
2975 2995 2985 0 0
2996 2997 2998 0 0
2999 3000 3001 0 0
3001 3002 2999 0 0
2973 3003 2987 0 0
2998 3004 3005 0 0
3006 3007 3008 0 0
3009 3010 2996 0 0
3011 3012 3013 0 0
3013 3014 3011 0 0
3015 3016 3017 0 0
3017 3018 3015 0 0
2991 2990 3019 0 0
3019 2971 2991 0 0
2992 2994 3020 0 0
2969 2971 3021 0 0
3022 2996 2998 0 0
3023 3024 3025 0 0
3025 3026 3023 0 0
2978 2980 3027 0 0
3028 3006 3029 0 0
3029 3030 3028 0 0
2981 2978 3031 0 0
3031 2973 2981 0 0
3032 2964 3033 0 0
2976 2975 3034 0 0
3034 3035 2976 0 0
3036 3035 3034 0 0
3034 3037 3036 0 0
3038 3039 3040 0 0
3040 3041 3038 0 0
3042 3043 3031 0 0
3031 3044 3042 0 0
2975 2977 2995 0 0
3045 3021 2971 0 0
3022 3009 2996 0 0
3031 3043 2974 0 0
2974 2973 3031 0 0
3045 2971 3019 0 0
3046 3040 3039 0 0
3039 3047 3046 0 0
3048 3049 2991 0 0
3050 3051 3052 0 0
3052 3053 3050 0 0
3054 2972 2968 0 0
3055 3056 3057 0 0
3057 3058 3055 0 0
2975 2985 2984 0 0
3016 3015 3038 0 0
3038 3041 3016 0 0
3010 3009 2984 0 0
2984 2986 3010 0 0
3059 3060 3058 0 0
3058 3057 3059 0 0
3032 2965 2964 0 0
3012 3028 3030 0 0
3030 3013 3012 0 0
3011 3014 3061 0 0
3061 3062 3011 0 0
2972 2974 2968 0 0
2974 3043 2966 0 0
2966 2968 2974 0 0
3063 3052 3051 0 0
3051 3064 3063 0 0
3006 3008 3029 0 0
3065 2991 2971 0 0
2971 2970 3065 0 0
2978 2982 2979 0 0
2989 2991 3049 0 0
3027 3044 3031 0 0
3031 2978 3027 0 0
3066 3067 3068 0 0
3068 3069 3066 0 0
2998 3005 3037 0 0
3037 3022 2998 0 0
3062 3061 3067 0 0
3067 3066 3062 0 0
3048 2991 3065 0 0
2981 2988 2982 0 0
3022 3037 3034 0 0
3034 3009 3022 0 0
3047 3070 3071 0 0
3071 3046 3047 0 0
2984 3009 3034 0 0
3034 2975 2984 0 0
3018 3017 2993 0 0
2993 2992 3018 0 0
3072 3073 3074 0 0
3075 3076 3077 0 0
3078 3079 3080 0 0
3081 3082 3083 0 0
3084 3085 3086 0 0
3087 3088 3089 0 0
3088 3090 3091 0 0
3090 3092 3093 0 0
3094 3095 3077 0 0
3077 3096 3075 0 0
3097 3095 3098 0 0
3099 3085 3100 0 0
3101 3102 3103 0 0
3104 3105 3106 0 0
3107 3108 3076 0 0
3076 3075 3107 0 0
3109 3073 3110 0 0
3111 3112 3113 0 0
3111 3114 3107 0 0
3115 3116 3117 0 0
3118 3119 3120 0 0
3115 3120 3121 0 0
3122 3123 3124 0 0
3124 3125 3122 0 0
3126 3075 3096 0 0
3096 3127 3126 0 0
3128 3129 3130 0 0
3130 3131 3128 0 0
3132 3119 3118 0 0
3118 3089 3132 0 0
3133 3134 3135 0 0
3135 3136 3133 0 0
3107 3075 3126 0 0
3126 3111 3107 0 0
3137 3138 3139 0 0
3139 3140 3137 0 0
3073 3085 3141 0 0
3141 3110 3073 0 0
3090 3087 3134 0 0
3134 3092 3090 0 0
3087 3089 3135 0 0
3135 3134 3087 0 0
3118 3115 3135 0 0
3135 3089 3118 0 0
3142 3143 3144 0 0
3144 3145 3142 0 0
3072 3146 3073 0 0
3147 3148 3126 0 0
3126 3127 3147 0 0
3078 3149 3079 0 0
3081 3150 3082 0 0
3084 3141 3085 0 0
3146 3100 3085 0 0
3085 3073 3146 0 0
3087 3090 3088 0 0
3077 3095 3096 0 0
3099 3086 3085 0 0
3151 3152 3153 0 0
3153 3154 3151 0 0
3101 3083 3102 0 0
3104 3155 3105 0 0
3089 3088 3132 0 0
3109 3074 3073 0 0
3156 3157 3149 0 0
3149 3078 3156 0 0
3158 3159 3145 0 0
3145 3144 3158 0 0
3117 3136 3135 0 0
3135 3115 3117 0 0
3107 3114 3108 0 0
3111 3160 3112 0 0
3111 3113 3114 0 0
3115 3121 3116 0 0
3161 3162 3157 0 0
3157 3156 3161 0 0
3115 3118 3120 0 0
3163 3164 3165 0 0
3165 3166 3163 0 0
3167 3168 3169 0 0
3169 3170 3167 0 0
3171 3169 3168 0 0
3168 3172 3171 0 0
3096 3095 3097 0 0
3097 3127 3096 0 0
3138 3104 3106 0 0
3106 3139 3138 0 0
3122 3125 3162 0 0
3162 3161 3122 0 0
3173 3174 3175 0 0
3175 3176 3173 0 0
3140 3174 3173 0 0
3173 3137 3140 0 0
3164 3163 3176 0 0
3176 3175 3164 0 0
3123 3128 3131 0 0
3131 3124 3123 0 0
3177 3178 3179 0 0
3179 3180 3177 0 0
3160 3111 3126 0 0
3126 3148 3160 0 0
3181 3182 3183 0 0
3183 3184 3181 0 0
3185 3186 3187 0 0
3187 3188 3185 0 0
3189 3190 3191 0 0
3191 3192 3189 0 0
3193 3194 3195 0 0
3195 3196 3193 0 0
3197 3198 3199 0 0
3199 3200 3197 0 0
3201 3202 3203 0 0
3203 3204 3201 0 0
3205 3206 3207 0 0
3207 3208 3205 0 0
3209 3210 3211 0 0
3211 3212 3209 0 0
3213 3214 3215 0 0
3215 3216 3213 0 0
3217 3218 3219 0 0
3219 3220 3217 0 0
3221 3222 3223 0 0
3223 3224 3221 0 0
3225 3226 3227 0 0
3227 3228 3225 0 0
3229 3230 3231 0 0
3231 3232 3229 0 0
3197 3200 3233 0 0
3233 3234 3197 0 0
3235 3236 3237 0 0
3237 3238 3235 0 0
3239 3240 3241 0 0
3241 3242 3239 0 0
3243 3244 3245 0 0
3245 3246 3243 0 0
3247 3248 3249 0 0
3249 3250 3247 0 0
3251 3252 3253 0 0
3253 3254 3251 0 0
3255 3256 3257 0 0
3257 3258 3255 0 0
3259 3260 3261 0 0
3261 3262 3259 0 0
3263 3264 3265 0 0
3265 3266 3263 0 0
3267 3268 3269 0 0
3269 3270 3267 0 0
3271 3272 3273 0 0
3273 3274 3271 0 0
3275 3276 3277 0 0
3277 3278 3275 0 0
3279 3280 3281 0 0
3281 3282 3279 0 0
3283 3284 3285 0 0
3285 3286 3287 0 0
3287 3288 3289 0 0
3289 3290 3291 0 0
3291 3292 3293 0 0
3293 3294 3295 0 0
3295 3285 3287 0 0
3287 3289 3291 0 0
3291 3293 3295 0 0
3287 3291 3295 0 0
3296 3297 3298 0 0
3298 3299 3296 0 0
3300 3301 3302 0 0
3302 3303 3300 0 0
3304 3305 3306 0 0
3306 3307 3304 0 0
3308 3235 3238 0 0
3238 3309 3308 0 0
3310 3300 3303 0 0
3303 3311 3310 0 0
3312 3304 3307 0 0
3307 3313 3312 0 0
3314 3308 3309 0 0
3309 3315 3314 0 0
3236 3310 3311 0 0
3311 3237 3236 0 0
3297 3312 3313 0 0
3313 3298 3297 0 0
3301 3296 3299 0 0
3299 3302 3301 0 0
3305 3314 3315 0 0
3315 3306 3305 0 0
3316 3317 3318 0 0
3318 3319 3316 0 0
3193 3196 3320 0 0
3320 3321 3193 0 0
3229 3232 3322 0 0
3322 3323 3229 0 0
3181 3184 3324 0 0
3324 3325 3181 0 0
3189 3192 3326 0 0
3326 3327 3189 0 0
3225 3228 3328 0 0
3328 3329 3225 0 0
3185 3188 3330 0 0
3330 3331 3185 0 0
3217 3220 3332 0 0
3332 3333 3217 0 0
3213 3216 3334 0 0
3334 3335 3213 0 0
3209 3212 3317 0 0
3317 3316 3209 0 0
3205 3208 3336 0 0
3336 3337 3205 0 0
3201 3204 3338 0 0
3338 3339 3201 0 0
3340 3341 3342 0 0
3342 3343 3340 0 0
3234 3233 3344 0 0
3344 3345 3234 0 0
3323 3322 3346 0 0
3346 3347 3323 0 0
3331 3330 3348 0 0
3348 3349 3331 0 0
3335 3334 3350 0 0
3350 3351 3335 0 0
3339 3338 3352 0 0
3352 3353 3339 0 0
3327 3326 3354 0 0
3354 3355 3327 0 0
3333 3332 3356 0 0
3356 3357 3333 0 0
3337 3336 3358 0 0
3358 3359 3337 0 0
3321 3320 3360 0 0
3360 3361 3321 0 0
3329 3328 3362 0 0
3362 3363 3329 0 0
3325 3324 3341 0 0
3341 3340 3325 0 0
3364 3365 3366 0 0
3366 3367 3364 0 0
3319 3318 3368 0 0
3368 3369 3319 0 0
3345 3344 3370 0 0
3370 3371 3345 0 0
3347 3346 3372 0 0
3373 3374 3347 0 0
3349 3348 3375 0 0
3375 3376 3349 0 0
3351 3350 3377 0 0
3377 3378 3351 0 0
3353 3352 3379 0 0
3379 3380 3353 0 0
3355 3354 3381 0 0
3381 3382 3355 0 0
3357 3356 3383 0 0
3383 3384 3357 0 0
3359 3358 3385 0 0
3385 3386 3359 0 0
3361 3360 3387 0 0
3387 3388 3361 0 0
3363 3362 3365 0 0
3365 3364 3363 0 0
3389 3390 3391 0 0
3391 3392 3393 0 0
3393 3394 3395 0 0
3395 3396 3397 0 0
3397 3398 3399 0 0
3399 3400 3389 0 0
3389 3391 3393 0 0
3393 3395 3397 0 0
3397 3399 3389 0 0
3393 3397 3389 0 0
3343 3342 3401 0 0
3401 3402 3343 0 0
3369 3368 3403 0 0
3403 3404 3369 0 0
3371 3370 3405 0 0
3405 3406 3371 0 0
3374 3373 3407 0 0
3407 3408 3374 0 0
3376 3375 3409 0 0
3409 3410 3376 0 0
3378 3377 3411 0 0
3411 3412 3378 0 0
3380 3379 3413 0 0
3413 3414 3380 0 0
3382 3381 3415 0 0
3415 3416 3382 0 0
3384 3383 3417 0 0
3417 3418 3384 0 0
3386 3385 3419 0 0
3419 3420 3386 0 0
3388 3387 3421 0 0
3421 3422 3388 0 0
3423 3424 3425 0 0
3425 3426 3423 0 0
3426 3425 3427 0 0
3427 3428 3426 0 0
3429 3430 3431 0 0
3431 3432 3429 0 0
3433 3434 3435 0 0
3435 3436 3433 0 0
3437 3438 3439 0 0
3439 3434 3437 0 0
3440 3441 3442 0 0
3442 3443 3440 0 0
3444 3445 3446 0 0
3446 3447 3444 0 0
3445 3448 3449 0 0
3449 3446 3445 0 0
3448 3440 3443 0 0
3443 3449 3448 0 0
3450 3451 3452 0 0
3452 3453 3450 0 0
3451 3454 3433 0 0
3433 3452 3451 0 0
3454 3437 3434 0 0
3434 3433 3454 0 0
3455 3456 3457 0 0
3457 3458 3455 0 0
3452 3433 3436 0 0
3436 3459 3452 0 0
3460 3461 3462 0 0
3462 3463 3460 0 0
3437 3454 3464 0 0
3464 3465 3437 0 0
3466 3467 3468 0 0
3468 3469 3466 0 0
3440 3448 3470 0 0
3470 3471 3440 0 0
3472 3473 3474 0 0
3474 3475 3476 0 0
3476 3477 3478 0 0
3478 3479 3472 0 0
3472 3474 3476 0 0
3476 3478 3472 0 0
3480 3471 3481 0 0
3481 3482 3480 0 0
3470 3473 3472 0 0
3472 3483 3470 0 0
3428 3427 3484 0 0
3484 3485 3428 0 0
3448 3445 3473 0 0
3473 3470 3448 0 0
3454 3451 3486 0 0
3486 3464 3454 0 0
3451 3450 3487 0 0
3487 3486 3451 0 0
3441 3440 3471 0 0
3471 3480 3441 0 0
3445 3444 3474 0 0
3474 3473 3445 0 0
3438 3437 3465 0 0
3465 3488 3438 0 0
3489 3490 3491 0 0
3491 3492 3489 0 0
3492 3491 3493 0 0
3493 3494 3492 0 0
3494 3493 3495 0 0
3495 3496 3494 0 0
3465 3464 3497 0 0
3497 3498 3465 0 0
3486 3487 3499 0 0
3499 3500 3486 0 0
3471 3470 3483 0 0
3483 3481 3471 0 0
3464 3486 3500 0 0
3500 3497 3464 0 0
3501 3502 3503 0 0
3503 3504 3501 0 0
3502 3505 3506 0 0
3506 3503 3502 0 0
3505 3507 3508 0 0
3508 3506 3505 0 0
3507 3509 3510 0 0
3510 3508 3507 0 0
3509 3511 3512 0 0
3512 3510 3509 0 0
3511 3469 3468 0 0
3468 3512 3511 0 0
3513 3488 3465 0 0
3465 3498 3514 0 0
3514 3515 3516 0 0
3516 3517 3513 0 0
3513 3465 3514 0 0
3514 3516 3513 0 0
3518 3519 3520 0 0
3520 3521 3518 0 0
3522 3523 3524 0 0
3524 3525 3522 0 0
3526 3518 3521 0 0
3521 3527 3526 0 0
3528 3522 3525 0 0
3525 3529 3528 0 0
3530 3526 3527 0 0
3527 3531 3530 0 0
3532 3528 3529 0 0
3529 3533 3532 0 0
3534 3530 3531 0 0
3531 3535 3534 0 0
3536 3537 3538 0 0
3538 3539 3536 0 0
3540 3534 3535 0 0
3535 3541 3542 0 0
3543 3536 3539 0 0
3539 3544 3543 0 0
3495 3542 3541 0 0
3541 3496 3495 0 0
3545 3543 3544 0 0
3544 3546 3545 0 0
3547 3548 3501 0 0
3501 3504 3547 0 0
3549 3550 3545 0 0
3545 3546 3549 0 0
3551 3552 3548 0 0
3548 3547 3551 0 0
3553 3554 3550 0 0
3550 3549 3553 0 0
3555 3556 3552 0 0
3552 3551 3555 0 0
3557 3558 3554 0 0
3554 3553 3557 0 0
3559 3560 3561 0 0
3561 3562 3559 0 0
3563 3564 3565 0 0
3565 3566 3563 0 0
3567 3568 3520 0 0
3520 3519 3567 0 0
3569 3570 3571 0 0
3571 3523 3569 0 0
3443 3442 3572 0 0
3572 3573 3443 0 0
3453 3452 3459 0 0
3459 3574 3453 0 0
3575 3576 3577 0 0
3577 3578 3575 0 0
3434 3439 3579 0 0
3579 3435 3434 0 0
3580 3581 3582 0 0
3582 3583 3580 0 0
3584 3585 3586 0 0
3586 3587 3584 0 0
3588 3589 3560 0 0
3560 3559 3588 0 0
3590 3591 3564 0 0
3564 3563 3590 0 0
3592 3593 3589 0 0
3589 3588 3592 0 0
3594 3595 3591 0 0
3591 3590 3594 0 0
3596 3597 3598 0 0
3598 3599 3596 0 0
3600 3601 3602 0 0
3602 3603 3600 0 0
3603 3602 3604 0 0
3604 3605 3603 0 0
3605 3604 3597 0 0
3597 3596 3605 0 0
3606 3607 3603 0 0
3607 3600 3603 0 0
3596 3608 3609 0 0
3596 3599 3608 0 0
3447 3446 3610 0 0
3610 3611 3447 0 0
3446 3449 3612 0 0
3612 3610 3446 0 0
3449 3443 3573 0 0
3573 3612 3449 0 0
3613 3614 3615 0 0
3615 3616 3613 0 0
3617 3618 3619 0 0
3619 3620 3617 0 0
3621 3622 3623 0 0
3623 3624 3621 0 0
3625 3626 3627 0 0
3627 3628 3625 0 0
3626 3629 3630 0 0
3630 3627 3626 0 0
3631 3632 3633 0 0
3633 3634 3631 0 0
3635 3636 3637 0 0
3637 3638 3635 0 0
3639 3638 3640 0 0
3640 3641 3639 0 0
3642 3643 3644 0 0
3644 3645 3642 0 0
3646 3647 3648 0 0
3648 3649 3646 0 0
3649 3648 3650 0 0
3650 3651 3649 0 0
3651 3650 3643 0 0
3643 3642 3651 0 0
3652 3653 3654 0 0
3654 3655 3652 0 0
3655 3654 3635 0 0
3635 3656 3655 0 0
3656 3635 3638 0 0
3638 3639 3656 0 0
3657 3658 3659 0 0
3659 3660 3657 0 0
3654 3661 3636 0 0
3636 3635 3654 0 0
3662 3663 3664 0 0
3664 3665 3662 0 0
3639 3666 3667 0 0
3667 3656 3639 0 0
3668 3669 3670 0 0
3670 3671 3668 0 0
3642 3672 3673 0 0
3673 3651 3642 0 0
3674 3675 3676 0 0
3677 3678 3679 0 0
3679 3680 3681 0 0
3681 3682 3674 0 0
3674 3677 3679 0 0
3679 3681 3674 0 0
3683 3684 3685 0 0
3685 3672 3683 0 0
3673 3686 3676 0 0
3676 3675 3673 0 0
3629 3687 3688 0 0
3688 3630 3629 0 0
3651 3673 3675 0 0
3675 3649 3651 0 0
3656 3667 3689 0 0
3689 3655 3656 0 0
3655 3689 3690 0 0
3690 3652 3655 0 0
3645 3683 3672 0 0
3672 3642 3645 0 0
3649 3675 3674 0 0
3674 3646 3649 0 0
3641 3691 3666 0 0
3666 3639 3641 0 0
3692 3693 3694 0 0
3694 3695 3692 0 0
3693 3696 3697 0 0
3697 3694 3693 0 0
3696 3698 3699 0 0
3699 3697 3696 0 0
3666 3700 3701 0 0
3701 3667 3666 0 0
3689 3702 3703 0 0
3703 3690 3689 0 0
3672 3685 3686 0 0
3686 3673 3672 0 0
3667 3701 3702 0 0
3702 3689 3667 0 0
3704 3705 3706 0 0
3706 3707 3704 0 0
3707 3706 3708 0 0
3708 3709 3707 0 0
3709 3708 3710 0 0
3710 3711 3709 0 0
3711 3710 3712 0 0
3712 3713 3711 0 0
3713 3712 3714 0 0
3714 3715 3713 0 0
3715 3714 3670 0 0
3670 3669 3715 0 0
3666 3691 3716 0 0
3716 3717 3718 0 0
3718 3719 3720 0 0
3720 3700 3666 0 0
3666 3716 3718 0 0
3718 3720 3666 0 0
3721 3722 3723 0 0
3723 3724 3721 0 0
3725 3726 3727 0 0
3727 3728 3725 0 0
3729 3730 3722 0 0
3722 3721 3729 0 0
3731 3732 3726 0 0
3726 3725 3731 0 0
3733 3734 3730 0 0
3730 3729 3733 0 0
3735 3736 3732 0 0
3732 3731 3735 0 0
3737 3738 3734 0 0
3734 3733 3737 0 0
3739 3740 3741 0 0
3741 3742 3739 0 0
3743 3744 3738 0 0
3738 3737 3743 0 0
3745 3746 3740 0 0
3740 3739 3745 0 0
3699 3698 3744 0 0
3744 3743 3699 0 0
3747 3748 3746 0 0
3746 3745 3747 0 0
3749 3705 3704 0 0
3704 3750 3749 0 0
3751 3748 3747 0 0
3747 3752 3751 0 0
3753 3749 3750 0 0
3750 3754 3753 0 0
3755 3751 3752 0 0
3752 3756 3755 0 0
3757 3753 3754 0 0
3754 3758 3757 0 0
3759 3755 3756 0 0
3756 3760 3759 0 0
3761 3762 3763 0 0
3763 3764 3761 0 0
3765 3766 3767 0 0
3767 3768 3765 0 0
3769 3724 3723 0 0
3723 3770 3769 0 0
3771 3728 3727 0 0
3727 3772 3771 0 0
3643 3773 3774 0 0
3774 3644 3643 0 0
3653 3775 3661 0 0
3661 3654 3653 0 0
3776 3777 3778 0 0
3778 3779 3776 0 0
3638 3637 3780 0 0
3780 3640 3638 0 0
3781 3782 3783 0 0
3783 3784 3781 0 0
3785 3786 3787 0 0
3787 3788 3785 0 0
3789 3761 3764 0 0
3764 3790 3789 0 0
3791 3765 3768 0 0
3768 3792 3791 0 0
3793 3789 3790 0 0
3790 3794 3793 0 0
3795 3791 3792 0 0
3792 3796 3795 0 0
3797 3798 3799 0 0
3799 3800 3797 0 0
3801 3802 3803 0 0
3803 3804 3801 0 0
3802 3805 3806 0 0
3806 3803 3802 0 0
3805 3797 3800 0 0
3800 3806 3805 0 0
3807 3802 3808 0 0
3808 3802 3801 0 0
3809 3810 3811 0 0
3809 3811 3798 0 0
3647 3812 3813 0 0
3813 3648 3647 0 0
3648 3813 3814 0 0
3814 3650 3648 0 0
3650 3814 3773 0 0
3773 3643 3650 0 0
3815 3816 3817 0 0
3817 3818 3815 0 0
3819 3820 3821 0 0
3821 3822 3819 0 0
3823 3824 3825 0 0
3825 3826 3823 0 0
									$end_cdata$
								$end 'file'
							$end 'files'
						$end 'node'
						$begin 'node'
							fullname='NODE-*-Scene-*-GPS-*-L1 Passband'
							$begin 'properties'
								AntennaHigherCutoffFrequency='1585500000.000000000000000000'
								AntennaHigherStopBandFrequency='1586000000.000000000000000000'
								AntennaLowerCutoffFrequency='1565500000.000000000000000000'
								AntennaLowerStopBandFrequency='1565000000.000000000000000000'
								Enabled='true'
								Name='L1 Passband'
								NodeOrder='1'
								NumberOfPorts='2'
								OutbandLoss='30.000000000000000000'
								Parent='NODE-*-Scene-*-GPS'
								PassbandLoss='0'
								Type='AntennaPassband'
							$end 'properties'
						$end 'node'
						$begin 'node'
							fullname='NODE-*-Scene-*-GPS-*-L2 Passband'
							$begin 'properties'
								AntennaHigherCutoffFrequency='1237600000.000000000000000000'
								AntennaHigherStopBandFrequency='1238100000.000000000000000000'
								AntennaLowerCutoffFrequency='1217600000.000000000000000000'
								AntennaLowerStopBandFrequency='1217100000.000000000000000000'
								Enabled='true'
								Name='L2 Passband'
								NodeOrder='2'
								NumberOfPorts='2'
								OutbandLoss='30.000000000000000000'
								Parent='NODE-*-Scene-*-GPS'
								PassbandLoss='0'
								Type='AntennaPassband'
							$end 'properties'
						$end 'node'
					$end 'EmitCouplings'
				$end 'CouplingFolderSettings'
				$begin 'ResultFolderSettings'
					NodeName='Results'
					$begin 'NodeSettings'
					$end 'NodeSettings'
				$end 'ResultFolderSettings'
			$end 'EMIT Design'
		$end 'Instance'
		$begin 'SODInfo'
		$end 'SODInfo'
	$end 'DataInstances'
	$begin 'WBSystemIDToDesignInstanceIDMap'
	$end 'WBSystemIDToDesignInstanceIDMap'
	$begin 'WBSysIDSysDetails'
	$end 'WBSysIDSysDetails'
	$begin 'WBConnIDConnDetails'
	$end 'WBConnIDConnDetails'
	$begin 'WBMaterialGuidDetails'
		WBMaterialGuidMap()
	$end 'WBMaterialGuidDetails'
	$begin 'MinervaProjectSettingsBlk'
		MinervaRemoteFilePath=''
		FolderContainerString=''
	$end 'MinervaProjectSettingsBlk'
$end 'AnsoftProject'
$begin 'AllReferencedFilesForProject'
$end 'AllReferencedFilesForProject'
$begin 'ProjectPreview'
	IsEncrypted=false
	Thumbnail64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCABgAGADASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+/iiiigAooooAK5Lxn4/8CfDnS4Nb+IXjXwl4D\
0W6v4tKtdX8Z+JNG8L6Xc6pPb3V3DpsGoa3ewRTX72ljeyrCrmRo7OVwpWNyOtrzP4x/Da3+Lvwz8W/\
D6bV7/w5d67YQy6B4p0q41S21Twh4w0S/tPEHgnxnpsmjavYXMl/o/i/StE1OGJLy3WeTSlhlkEUjg9\
GEjhpYrDxxk5U8JKcVUlDWUYNpSlFWldxV5JW961tL3PH4hq53QyLOK/DeHo4ziChhq08FRxDcaFfEw\
pylRoVZKpTdOFaoo03U50qXN7RqSi4vkv+GqP2Yf8Ao474Df8Ah3/h7/8ANDXtWlarpeu6Xput6JqVh\
rOi6zYWeq6Rq+lXlvqOl6rpeo28d3p+pabqFpI8V9YT2k0MsM0TtHLHKrozKwJ/IXWtc8f/AB8+Ndz8\
KNf8OaDcfE+TwF4G0z4+/CjRPi18SPhT4M17wP8ADXVf21fAPii71Txn4c0KTXdP8BaxrnxI+CHiHSt\
EubC7vNU0n4g6LLLDe6ML3WYf09+C3gzVPhz8HPhN8PdbnsLrWvAfwz8CeDNXutKluJ9LudU8L+FtK0\
TUJ9Nmu7WCWawe7sZmhaWCGRo2UvFGxKD6DPsmwWU0MPyVZxxtXkk6cqlKrF05wb5oShGEmozjZTcPZ\
1IyhKnOTc4w/H/CXxM4m8Qc0zh4nA4arwzgfrNGnjKOCx+BrRxeGxNOn7DE0MVVxNKnOrh6qqSw8cQ8\
ZhK9HEUMZh6MY4ativTKKKK+XP3gKKKKACiiigAooooA8f8A2hfgp4V/aU+AXxw/Zz8dah4g0nwT8fv\
g/wDEv4KeMdU8J3WnWPirTfCvxU8F614F8Q6h4ZvtY0q/tLPxBDpGu3kllLdWN7bR3Mcbz2lxEGhf4T\
/Z1/4JyfBD/gnP+xTY/Av4Gah+1X8VfDvwD8G/FfxL4I0DVP2k/i9ofjXxzquseI/G/wAWJPC8WmfBK\
80HQ7XUbzxL4ju7Cz/sjwrFK6ywST22o6i9xcXf6mV5J8a/H/ij4Y+B28Y+GPCmg+LfsGveHLLxDD4k\
8Y6h4H0jw74X1rV7XRtW8b6nr2n+Ctd+y6Dov2+31LWJZ7aC3stD07U9Tluh9hW3uevA/XZYmnQwFee\
HxOKapxlCpGlJubVlzyagrytbnvG6V09j5ziuPDFPJMZmPGGWUc0yLJYyxlaFbBSx6pxoQm51YYaFHE\
VZThSdRXo0pVFCU7KzZ+d/7MXxW8d6P+0JBoFj+wD8efh1oHx18ReMvDfxG/aP8e/FX4p/EC0trj4B+\
G/En/CJ6j4msPi1oQ12x0HWIrrTbTwtqFymnWOpWusPCbkX2mRaU/6118da98e/jd4X1T4j6f4h+E3w\
V0q0+FXwz0H4s+MNbk/aA+It3pdr4P124+I8Ims4dN/ZZnvb+/tY/hd4jmuYI7MsY57QWxuZZZIofqf\
wrqGuat4X8N6r4n8Pf8Ij4l1PQdH1DxD4U/taz1//AIRjXL3T7e51bw9/bunotvrX2K/luLb7XAqw3P\
2bzolCOorrzLDZnCnhcRmdSOIrezpUnXeIhXq13GlGUKlTlrVFzKjKlG1KFKjCn7KKpxbvL5rgDOODJ\
xx/DvB9Kpg8HgauKxCwn9iYnKKGF9pja9LFRUZZdgMO51s0p5hVnPl9ticR9cqN1XSqzjvUUUV5J+kB\
RRRQAUUUUAFFFFAHn/xZ+KXgT4HfCz4l/Gv4pa7/AMIv8Mvg/wDD/wAZfFL4i+Jv7M1jW/8AhHfAnw/\
8Oal4s8Xa7/Y3h3T7vUNX+yeH9I1C4+y2NpdXlx9n8q1t5p3SNvkf4Wft9/8ABPf9tH9n638feAf2l/\
hJ4v8Agl8ZNB8a+GFbxP4qu/hHrmtaHDqviH4d+LrG+8I/ET/hH/E3hjdf6XrlvFLcWNjNNCsd9YyPb\
T2t1J9seLPCfhXx74V8TeBfHXhnw/408E+NPD+s+E/GPg7xZo2neI/Cvizwr4j0650fxD4Z8TeHtYtp\
rTXvD9/pF5eWt7ZXUMttdW11JBPG8Tsp8TvvgJH8OfgEnwP/AGMP+FUfsf22iXenyeAE8FfAvwrqfwy\
8BWN58QLbxl8QLXR/gz4d1Tw5pa3OuWl54xjM0U9uttqvit9cmhv5opLW66MLUpUq0alWNR8lnF06ip\
SjNNNS53Tq7We0U72aatZ+Nn2CzDMMuq4PL62DpvEKUK0cdgp4+hWw86c4VKEsPHGYFN1OaKbqVZU3D\
nhKnLn5ofnn+z5D4w+N/wC1N4j8E3XxBsPin8HP2drD4UXmtfFjSfHyeML/AOMVx4A8XfGLxv8AsyaV\
4j8R+E77RYtSv7C0+KMN54iZ9P1u1vPE3wCie+ufM1AmX9mK+NdC+BH7U2im/jvP23vEXi2LXvEmiaz\
q934p+A/wkj1jw9omiWGgyv4J+GEngu20XT/Dmgan4isfETatdeINM8W65Jo/if8As7TNX0rUdPsteT\
7Kr0M6zueeYijiPqSy6jSpU4RoqUZWkoRVWpJwjGnz1Jq75IqMIqFGF6dKEn8L4TeGq8NMhx2XYjO6v\
EuaZpjcVi62Mr03TqKjVr1KmDwMIzxGLqrD4DDzjRUquMxFTE4t43MaslXx1W5RRRXjn6mFFFFABRRR\
QAUUUUAFeK/tAQ/EAfDPVNX+Gvibxb4c8QeFr/SPFV/D4G0Lwp4l8V+KPB+iX8V1468I+GtE8X+D9at\
tS8W3vhD+2hoMKW9u03iCDSobi8i0+S9SW1+0L8R/FXwc+AXxw+LvgX4Y+IPjZ42+Ffwf+JfxH8HfBn\
wm2op4q+LnirwP4L1rxP4e+GPhl9H8P6tdr4g1/V9Ls9Ksja6VqdyLnVozBp97LttpPkX9jH9tb9oT9\
pj9mr4b/G74rf8ABOX9pv8AZt8feNv+Ew/t74LeK9d+FcWv+DP+Eb8feKfCOl/b4/i/4r+H/iJf7R0X\
QdO1aL+0fCOk5h12M2n2+xNtqd725eprF0asIUaroSU3CvKjGnNRkrxl7ZqElK9nHV2u0tG18xxjLDT\
4ezLA4rE5jgY5rSqYWOIyuhmNbG4epVpT5K9L+zKdTFUZUnHnjWXJBTUISmnOMZWte1/4had4o8aaX4\
b/AGn/AIt+O7b/AIVJ8IfGPwa0nQLH9mH+0Piz44+KWofHNNL8N6R4htf2dLy0fQbrSvhfo94upx2rW\
ekaX/a/iDVbn+xbKe4svvLwrp+uaT4X8N6V4n8Q/wDCXeJdM0HR9P8AEPiv+ybPQP8AhJ9cstPt7bVv\
EP8AYWnu1vov22/iuLn7JAzQ232nyYmKIpr8/v2c/gN8UbH9qb4xfGXx5oXi3wl8MRYTD4OeB/iBdfC\
zXdZh1/x/4u8a/EXxr4i874Y+LNStdJv9F8U/EH4s2Gk3F19p1J9B+MF1YLqawJe20/6P17XEs8JTr0\
MHgqmGxEIUqNSdWhSoR9+dGn+7c6MIxcoayqqMpRVac4Nt048v5j4H4XiHF5Xm3EfEuEzrJ8TiMdmWD\
w2CzbG5rWaw2HzPF2xsMNmeJq1qdLE+5SwMq9GlVlluFwuJpwpxxtX2pRRRXzB+6hRRRQAUUUUAFFFF\
ABXkXx2+DmifH74V+JvhN4i8QeKPC2j+KZfD0t3rvgyXw/D4ksj4c8UaL4qtl06TxT4d1awVZrvQ4IJ\
/PsJyba5mEJhnMU8XrteDftK/C6z+LPwg8TaH/wAIdoPjvxL4f+yeP/h74a8SWGh32kav8RPA048ReE\
9D1MeIAtvDoOr39l/Ymsfv7NrjQ/Eup2X26zS6e4TowlKjXxWHoV631ejWnGMqjipKCk0nJxlKEWo3u\
05RVr3Z4/EOYZjlWRZxmmU5a84zPLsNWr0MJGrUoTxNSlTlONGnVo0MTVhUqOPJTdOhVnzuKjFtnyF4\
n/4JS/s/eIvBuq+DbX4m/tTeGoda8X6f4v1DVtL/AGgfFut3M0lj8NrT4WSeG08P+PU1nQIPB0vhi1k\
CaamjrBpsmpX0ei/2ZZ313aTfptX4z3cH7NPjL4j3Hhz4Y/AH4Z6X4v8Ajt8M/hD4N+GfhTxP8GfhVo\
uv/CTxha+Nf2s9K+NnxG8Q/Dfxtp0UVxf+CbT4fS/25Z20Vyusal4T0XQhcvbahY30f69eFfDGh+CfC\
/hvwZ4Ysf7M8NeEdB0fwx4e037TeXv9n6HoOn2+laTY/bNQuJbi78qwtLePzZ5ZZpPL3SyO5Zj6ma5L\
SyOjh8NGrUhKq+dUZ0IUeROlRhOXLGtUsk4RoJKKi50Kuzi+b8/8NPEjEeIcszqYfLMFSybKeaksXgc\
yr4+hUqvE4hUqcOfLMDT56mEjSzCb53Up4THZanGcK0XR3qKKK8M/WAooooAKKKKACiiigDx/9oXRvj\
L4j+AXxw8Pfs5+LPD/AIC/aD174P8AxL0b4E+OvFltBeeFfBfxl1TwXrVj8MPFniazuvDOtRXXh/TvG\
0+h3l7HJo2rRvbWcivpl+pNrL+Uvgb4/wD7XX7B37L/AMENE/4KkftmfAvxf+0r4gi+Jcmv+LvhR+xT\
+0J8dIfHZ0n4lsdIt/D1j+zta+E/7QvtP8CeOvh5BNb2/gHRJ/J03Ubzy9Vt9J1jX3/bqirhWr0G54d\
01Udl+9owrx5eaLlaE9FJxTUZrWLd7SjeMvOzLKsHm9GlhsbUxVOhTqRqf7JjcXgKraUo2dfBVqFVxc\
ZP3JSlTcuWcqcpQg1+JXwy/aB/Ya+AHx6+Mnxw8fftG+B/EXxz+LXgLTvF6/CD4UfAv4s6T8T9C+HUE\
Gpa34w8caX+zd4N1bxh4u8Q6T4gXwRpHiTUNVl0eSeFVi1WSaK38Rw/af2D+HvjrRPib4L8O+PvDcOs\
w+H/ABTp66ro39v6Jqfh3VLjTZpZEs76XSNYt4ri3triGNJ7Z3jUT21zDcR7opUY9lRWuLx+Z5lWp4j\
M8XHF14UqVLmVNU0o0aVOnBQhF8kIpQk+WMdeZXbmpzqeVwnwbwzwLluIyXhPKllOVYjFYrHSp+1rV6\
tTGY+vUxePxGIxOIqVa+IqYjF1alSEqk/3FF08NC9KjT5Siiiuc+mCiiigD//Z'
	$begin 'DesignInfo'
		DesignName='EMIT Design1'
		Notes=''
		Factory='EMIT'
		IsSolved=false
		'Nominal Setups'[0:]
		'Nominal Setup Types'[0:]
		'Optimetrics Setups'[0:]
		'Optimetrics Experiment Types'[0:]
		Image64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCADIAMgDASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+/iiiigAooooAKKKKACiiigAooooAKKK5Lxn4/\
wDAnw50uDW/iF418JeA9Fur+LSrXV/GfiTRvC+l3OqT291dw6bBqGt3sEU1+9pY3sqwq5kaOzlcKVjc\
i6dOpWnGnSpyq1JuyjFOUm+ySu2/Q5sZjcHl+FrY3MMXSwODw0eapWrVI0qVOO3NOpNxhGOu8mkdbRX\
g3/DVH7MP/Rx3wG/8O/8AD3/5oaP+GqP2Yf8Ao474Df8Ah3/h7/8ANDXb/ZOa/wDQsxH/AIJqf/InzH\
/EQ+AP+i5yf/w54L/5ee80V5n4M+NPwc+I2qT6J8Pfiz8M/HmtWthLqt1pHgzx34W8UapbaXBcWtpNq\
U+n6Jqs8sNgl3fWUTTMgjWS8iQsGkQH0yuStQr4efs8RRnQqJX5ZxcZWeztJJ2Z9Dlua5XnOFWNyjMs\
PmuDlJxVbDVqdek5R0lFVKUpQco9Ve66hRRRWR3hRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUU\
UUAFFFFABWD4q8MaH428L+JPBniex/tPw14u0HWPDHiHTftN5Zf2hoevafcaVq1j9s0+4iuLTzbC7uI\
/Nglimj8zdFIjhWG9RVQnOnONSnJwnBpxkm0007pprVNPVNapmOIw+HxmHr4TF0IYrC4qEqdWlUjGdO\
pTnFxnTqQknGcJxbjKMk4yi2mmmeSfBTxPrniLwOtj4vvv7Q8deBte8R/DjxvezW1npeoaxrngnV7rR\
bTxpqPhyyt4k8Kf8JT4ah0DxbZacqGG30vx3YG0nvLGS1vbnwbwL4v8AFHgn9iT9m7VvBkug2/iXU/A\
X7IfgjTbzxPpGoa/oen/8LK1n4TfDq81O+0XStf0u41T7LYeKbq4ihj1C08ya2jVpQhYH1vXv+LbfF/\
RvFqf6P4L+Mf8AZ3gTxrj9zp+jfE/S4Jv+FYeMrvHkWmnf25pS6h4R1PUbuW61DU9Us/hpoGnwrHG9f\
O/hOzuPHX7Mn7GHwW0XVb/QfEHjT4Z/AT4hT+JtKj0ubVPBPg/4Fab8LPiDqfjDTbLxDptxp2s37eOI\
vhr4fhtLhJ2ik+Ia6w+napp+j6lZv9XhqNGq1ieSEcDicXhMROLj+7p04Qxk8TBwSd4UlCpaCi5SpKH\
LBucYv+fs8zPMcDCeTfWsRW4pyPh/iDKMPUjVaxeLxmKxPDeGyTERxE5w5cRmE8Tg3PFVKtOhQx08Qq\
uIpww1WrD1v4R2XjvS/j/8cLD4jeJPCXjLxBc/DP4B65YeIPCngrWfANvpvhu813476PY+CV0XUfH+v\
rd2FprXh7xFq8d7JP8A2hLdePr62uJ5dPtNItNP+pq8k8AfCmXwT4o8V+M9W+I3j34keJfF2g+D/DF5\
qXje3+Hdl/Z+h+B9Q8a6rotjpln8O/AGgW65v/H3iGSaW4iuJpPMiVZESIKfW68PNa8MTjHVp1IVYql\
QhzQh7ODlToUqcuWHJT5Y80Xb3I33tqfqnAGVYrJeGoYLF4TEYCrPHZtiFRxWJ+uYmFLGZtjsZQVfE/\
WcX7Wq6Nem5v6zW5W3HnfLoUUUV5x9mFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAV4B+1\
j8dP+GX/wBlj9pb9pf/AIRb/hOP+Gd/2f8A4yfHT/hCv7b/AOEZ/wCEw/4VJ8OvEfj/AP4Rb/hI/wCy\
NQ/4R/8AtD/hH/sn277BffZPtfn/AGO58vyX9/rn/FnhPwr498K+JvAvjrwz4f8AGngnxp4f1nwn4x8\
HeLNG07xH4V8WeFfEenXOj+IfDPibw9rFtNaa94fv9IvLy1vbK6hltrq2upIJ43idlIB+In7JP/BZTx\
18c/2rPE/7Mnxo/ZA134OLofw++J3jCx8Y/D+H9tb4p67eax8Mh+yfeX3h3X/hD8VP+Cdfww8R+A2ud\
G/at0G48rV7a21+xg8P2Gsaj4ctfCHj74aeKvGH6xf8NHfD3/oXvjz/AOIr/tPf/Ogrmfgp+xF+xf8A\
s1+KtQ8dfs5/sifswfAHxtq3h+68J6p4x+CnwC+FPwr8Val4VvtR0rWL7wzqHiHwL4TsLu88PzavoWh\
3UtlJM1tJc6NaTvGZbeFk+n67KU8vUEq2GrVJ9414QW38rw83vf7T006XfzeOwvF9TESllmeZbhMK72\
hXyrFYiovedr1aec4WLtHlTtSV5Jy0UlGPyV8Ufix8PfiR8PPGPgeOx+POg3/iLQb+y0LxOn7JX7T1/\
eeD/FCRG58KeN9Jt1+Fdu669oniWDStW0+WG5tri3vtHt7i2ura4ijnjwP2JPhv8T/Cnww8MeJ/jJa6\
DpHjS/8AhJ8GPhvonh7w7B4hsP7E+GHwz8PatqHgu18caT4psY7vTfi2mq/EHxhB4gjhkbT1+wWMVpB\
byRXTTeLeJ/2y/Geg/GDxh8ITd6cfiEvjDWfDeneAoPByXGm+DPDVr49+Gek+DPFWqeOp/FkMeq6zr3\
w8+I+ma0Ybe3vobO48RaZptzZ2Mulay15t+If2h/j18K/jP8Lfh38Y/EPwbsIviP4y07SvCmg+CdC8d\
ax4p1vwt4i8b+FfCGkzeI/7SsYdKXxDAmqX51O5tdb0i20yWaG90/S/FsZfSbftoZxTr5Zh8oy+i6WH\
z+phqlN1qkJynObajToyjRpOTbivaKDqqbpRVBybfP8AKPw9xFXjnDeIfEWaUszzbgzC43BQWX4Wvg8\
O6dSdOEq+JhWzLHwrKksRWjg6kFh+aOKrylLEJ4dU/wBIqKKK8Y/TwooooAKKKKACiiigAooooAKKKK\
ACiiigAooooAKKKKACiiigAooooAKKK8z+LvxKT4Q+BNc+IV34O8W+M9F8L2Gp634ltfBj+Dxqmi+G9\
E0bU9b1nxHPD4y8XaPFe2FtaaYytBZz3OoSSXUQt7KZfNeLWhRqYmtToUYqVWtJRim1G8noleTSTb0V\
2rvQ4M0zPBZLl2NzbMasqGAy6lOtWnGnUquFKmnKc/Z0YVKkowinKXLB2inJ6JtemUV4N/wt/wCIX/R\
q/wAef/Ch/Zh/+iOrB8K/tDeJvG3hfw34z8Mfsy/HnU/DXi7QdH8T+HtS/tj9myy/tDQ9e0+31XSb77\
HqH7Q8VxaebYXdvJ5U8UU0fmbZY0cMo7VlOLcJVFKg4RaTl9awtk5JuKb9tZNqMmlu1F22Z8xLxB4dj\
iKWElRzWOKrwqVIUnkGfKpOnSlTjVqRh/ZvNKFOValGpJJxhKrTUmnON/peivFfAnxivfGfjvX/AIe6\
p8JPiZ8PNa8N+EtA8Z6ldeM7z4UXmljS/FWs+INE8NwQTeAPijrsst/d3fhHxYyr5Ajhj8PSm6lga4s\
Eu/aq5MRhquFqeyrKKnyxl7s4TXLNKUWpQlKLUotSWuzT2aPocmzrL8/wX9oZZOrPDKrWot1cPiMLNV\
aFSVGtB0sVSo1YypVYTpTvBWqQnD4oySKKKKwPVCiiigAooooAKKKKACiiigAooooAKKKKACiiigAoo\
ooAKKKKACiiigDwb4I/8Ud/wk/wIuPl/wCFQ/2L/wAIN/F9q+B/ir+1v+FU/wCr83yP7G/4R7xV4N/0\
y8udX1H/AIVR/wAJFqXl/wBu22/B/Z+8T6H4O/ZF/Z+8R+I777BpVh8BvgukkiW15f3l1eX/AIJ8Lab\
pWk6TpWm2813rmvX2q3llZafp9lBcX2o31/b2Vlb3F3cQwvvfF3/ijfFHw7+NzfPpXgf/AISDwJ4/83\
5oNJ+GHxU1Dwh/bnjKPPlR2H9heNPBXw71PVtRvbuHT9M8H2Hiq9mhuLuKx8rwb4G/8V14A/Yu+H1v+\
90r4cfAb4L/ABu+IUU377T7rz/hvceEfg54Y1HSLry49U+1eNLfxP4psr2Jrz+xdU+AthJPaW93qOj6\
hB9UqEMbgMRjqjcaGIq0auIasrVKVLF+2ipNcsZ15OnKC5VCM8TTpRi0lf8AAZ5piOGeLMo4UwcIVM1\
yfAZlgcop1FKSqYLH47h3+zqsqMJKtVw2V0Y4uhiZKtPE18NkeMx1WrTlObp/S/wa8Ma5onhe/wDEPj\
Kx/s34h/E3Xrr4j/EDTftNnef2FrmsafpelaN4L+2aVcPY6n/wjPgXQvCHhj+0bJLeHWf+EM/tqWBbz\
Ubpn9boor5vEV54mtUrzSi6jvyxuoxW0YQTb5YQilGEb2jFKK0R+2ZPleHyXLMFleGnOtTwcFF1arjK\
tXqNuVXE4icYwVXE4mrKdfE1uVSrV6lSrL3psKKKKxPSCiiigAooooAKKKKACiiigAooooAKKKKACii\
igAooooAK+YP23fDPxl8afsX/ALXfg79nO58QWf7Qfiz9mD4++GfgTeeE/FkHgLxVa/GXXfhT4s0v4Y\
XPhnx1dazp0XgvxAnja60NrLVpNQsI9OuVjvHvbVYTOn0/RQB/ML/wTe/Zs/4K1+Af21vG3jL4rXP7Q\
fw0+AN58HvixpOnn9qv4y+Nf2jvhxqXizVtR/Y6f4e23hH4KXf/AAWa+OWp+Ategl8H/tGSxT3etapc\
6eup61f3HjfVNN8d+Hfhz8Jf6Af+Ee/ae/6K/wDAb/xHH4hf/RUV7zXM+NNH1TxD4O8WaBoesT+Hta1\
zwzr2j6Pr9rJcQ3Oh6pqel3Vlp+sW81nLHLFPbXc8M6NE6SK0AKOrAEdSzCvhqMuSlSqKmm7PDUKknZ\
bJypSk27bXbb82z5/EcJZTmuNhVxeOzHCutJRlKjnOcYalBSm25exwuOpU0o8zdo07qKUI+7GKXjuq+\
Cf2itd0vUtE1v4m/s76zous2F5pWr6Rqv7MvjnUdL1XS9Rt5LTUNN1LT7v9qR4r6wntJpopoZUaOWOV\
kdWViDf/AGcP2e/A/wCzP8MNK+G/gi3/AOfHV/F+s+bq/wDxVvjj/hHtC0HX/F/9navrV/8A2D9v/sG\
0l/s+1n+x2v8Aq4V+87/J/jf9nX9s/wCIR+JuvQ/tCah8H9U8SWPwzh8JfD/4efFPUPEngSC58Nf8Ix\
D4wXXfFPiv4Fw634ft7yPSNYmjk8LLolxeS61LHq0lzE4MX0xdfBnxzp/ga58CeFPiUYNF8QaB410/x\
nNrlhrNp45vNR8QeDBoGg3Pw++Jvw38SeHJvhjcWOtRx3kuof2TrOoOnFhJpl0kd0uuKzbMv7PxmGjO\
P1Z2q+wpQp0VXnT9sqXMqNNJvlScVUblB1UpQjKLS87K/D3hPDcTZRxFUy+rW4hwlCrhKOYY/G43Mqu\
AoYqnga2LpUKuOxWJdGNSq/Y1ZYfljWeDn+8lSkfSNFYfhiw1DSvDXh7S9Wuhe6rpuh6TYanerNPcrd\
6hZ2Fvb3t0txcoslwJLmORw8iq779zqGJFblclaEadWrThUVWFOUoqS2kk2lJeUlqvU+rw9SdahQq1K\
ToVKsIylBu7hKUU3Bvq4t2b7oKKKKzNgooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiig\
AoorzP4u+G/iB4o8Ca5p/wALfH9/8OfH0Nhqd54U1u2svCl9pd1r8ejanDoeleK4fFngrXlXwk+tXGn\
zXzWNnHqQjsQLW5QGSKbWhTjWrU6Uq0MPGpJJznzckb/alyRnLlXW0W/I4M0xtXLcuxuPo5biM3q4Ol\
OpHC4X2LxNdwTfsqCxFbD0XVla0FUrU4t6cyuemUV8s+A/Cfi74heD9A8ZaR+1D+0RY2mu2CXMukax4\
Z/ZZttf8OapC8lprfhTxRp9r+z3OukeLdJ1q31DTdWsTK8lhqWlXVnMRLA4GB8FvCfxV+I3wc+E3xC1\
v9qH41WutePPhn4E8Z6va6V4Z/Zpg0u21TxR4W0rW9Qg02G7/Z7nlhsEu76ZYVlnmkWNVDyyMC59OeU\
xpwxE6maYeH1apGlNOOKupyVRpW+rdPZTv2aXc+Gw/iHXxmIynD4TgTOMR/bmDq4/DThWyB06mGoywc\
ZVFL+3Fbm+vYdwTV5RlJ6crPsWivmj4NW3j24+InxNu7/4xePfiP8ADbwt/ZvgDQY/GGi/CSyi1T4ia\
dLcal8R9c0rVfhx8MNG/tbQdM+1+HfDsOLvda+ItB8ZabqdiZtPsJo/peuHGYV4Ou6DrwxDUYS5oc9l\
zxU1FqpCnJSipJSTjpK63TPquG8+XEmVrNI5XicphKtiaKpYp4Z1JfVq9TDyqxeExOLoSo1ZUpToTjW\
ftKThUsoyVyiiiuU94KKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAoorn/Fnizwr4C8K+Jv\
HXjrxN4f8ABfgnwX4f1nxZ4x8Y+LNZ07w54V8J+FfDmnXOseIfE3ibxDrFzDaaD4fsNIs7y6vb26mit\
rW2tZJ55EiRmAB0FFfMHwU/bd/Yv/aU8Vah4F/Zz/a7/Zg+P3jbSfD914s1Twd8FPj78Kfip4q03wrY\
6jpWj33ibUPD3gXxZf3dn4fh1fXdDtZb2SFbaO51m0geQS3EKv8AT9AHg3gT/i33xP8AGXwrl+TQfGf\
/AAkXxu+Gn8Xlf2v4hs/+F4eGPl86aT7F8SfFekeJPtuoXEX2n/heX9j6RaLYeGZfL4P4OeN/+EG/ZF\
/ZlurPTP8AhIPEviD4SfAbwh4M8MJe/YZfEHijxB4J8OW1rFLcRWlzcW2g2Fgmpazrt3aWWoXGl+HfD\
Wr6wun3iafJA/pfx60rVG8CP458M6bf6v44+Dt+3xZ8E6RpVncajqniLVPDOjaxaa/4H03T4I5hLf8A\
ifwDrHjHwvDO1pfyadJ40XVbKyn1GxsgPkr9grxnpfx8+HHwn8ZWcF/B4W/Z2+Gfhb4I6LpGsxW8VxP\
8Y9P8FeHrT4leOjp8V1eW0thb+EH8Mab4V1OKWx1SG18a+NrO/tFtdStxX11HDxxmTYvN6sOehQrYZY\
lXs5VoUsTGF7Pmtieel7Spzc7qfWamiUb/AM65lm9bh3xM4d8OsBiPqua5tludSySfIpRoZdicdklbF\
KPtI+w58lWHx31TCKj9Wp4NZNhH7SVSty/cfwx8Ef8ACu/A+ieFZtT/ALe1W3/tLV/FPiT7F/Zf/CVe\
OPFOr3/irx74v/sdLuePQ/7W8aa1r2pf2fbyGzsP7U+x2Sx2kEMad5RRXytarUr1aterLnq1pSnJ2Sv\
KTbbskkrtt2SSXRH79l2AwmVZfgcrwFL6vgMto0sPQp80p8lGjCNOnDmnKU5csIxXNOUpO15SbbYUUU\
VmdgUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABXgH7WPwL/4ag/ZY/aW/Zo/4Sn/hB/8Ah\
oj9n/4yfAv/AITX+xP+Em/4Q/8A4W38OvEfgD/hKf8AhHP7X0//AISD+z/+Eg+1/Yft9j9r+yeR9stv\
M85Pf6KAPwk/ZJ/4I1+OvgZ+1Z4n/ab+NH7X+u/GNdc+H3xO8H2Pg74fzftrfCzXbPWPiaP2T7O+8Ra\
/8Xvip/wUU+J/iPx41to37KWg2/m6vc3Ov30HiCw0fUfEd14Q8A/DTwr4P/UzX/gb8KfC+ha14l13xX\
8ebHRPDuk6lrusXv8Aw1D+1Pc/Y9K0mzm1DULr7NZ/FmSa48u0t5n2RRvI+zaiMxCn6Pqhqul6drml6\
lomr2cGo6TrFheaXqmn3SCS2vtO1C3ktL2zuIz9+CW2mlRx3VyK6lmOZ0KMoYTG1aTSfLFVakIc1rRv\
yvRaJNpNpbJ2sfP4jg3grNMbDF51wpl+YznJe1qVMDhKtdwc3Kdp1aUm5NynJcza55Nu93f8+PH3xA/\
Yb+Fuu6z4W+If7RHxM8H+J9Ej8PSTeG9d/ar/AGr7HXtU/wCEph0e40aLwrpEvxQ+0eNbhoPEGjPcRa\
PHfSWKajG18tspJH1N8NPHHw0tPhTpTfDiy1afwJ4CsPD/AIF0HRdCtdQ8Y6tbafpmn6LpPh/TreHSr\
vUbu7ijsbvTEkurqU+TDFLe6hPFbxT3S4cH7J3wJi0Pxr4euPCuu6zYfEW08K2Pja48TfEr4o+LNc8Q\
2vgiWwm8KxXvifxN4zu9TAs30yxCGO7RnS3EcpkQsp6n4r/s/fB343+HoPDPxP8AAum+JbKx0nWNC0n\
UkutV0Lxd4e0fxHYRaR4m0/wv488N6hZ654VttV0SEafqo07UbX+09Omm0+/NxZTzQSGJxuNxNKpTq4\
2tietNVakpQjO9SzcXKTlaLpw5lKLf7ySUFaDMo4V4byPFQxWUcO5fk9epTdKtWwmCoYerKDpYSUoRl\
ShB+zni44mbpynJQpU8Jd1KntJQ73wX4w8PfELwh4Y8d+Er86p4W8Y6DpXibw7qbWl5YnUNE1uyh1HT\
L0WeoW8U9ustncQuEljRwHG5Qa6asjQNEsfDWhaN4d0ttRfTdB0uw0fT31jWdZ8R6q1lptrFZ2ral4g\
8RX91f63fGGFPNu725uLq4fdLcTSyuztr1hU5Oefsr+zu+Xmtzct9L20vbe2lz3afPyQ9okqllzWd1e\
2tnyxur7PljfflWyKKKKgsKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAK5Lxn4/8C\
fDnS4Nb+IXjXwl4D0W6v4tKtdX8Z+JNG8L6Xc6pPb3V3DpsGoa3ewRTX72ljeyrCrmRo7OVwpWNyOtr\
kvH/AIM0v4jeBPGvw91ue/tdF8eeEvEngzV7rSpbeDVLbS/FGjXuiahPps13azxQ36Wl9M0LSwTRrIq\
l4pFBQ7YdUHXorFOSw7klNwspKLerjdSV0tUrO9raXuebnEs1jlWYzyKNGecwo1JYWOIUpUJ14xbpwq\
8lSlJQnJKEpKcXDm5/e5eV+Z/8NUfsw/8ARx3wG/8ADv8Aw9/+aGj/AIao/Zh/6OO+A3/h3/h7/wDND\
XW/CbxnqnjPwfDL4ngsNP8AH3hq/vvBnxK0jTYri1sNN8d+HHW01qfSNP1C6lvbPwlqkZs9c8ONf+Xe\
XvhnxTo2pyxRi+QVyX7K/wDybD+zj/2Qb4Qf+q98O169XDZbRpYudTCYhTwlanScViabUueNaXMpfVf\
h/daWTUlJNNJa/nWBzrjXMsdw/h8Hn+UTw3EGXYzMIVJZJjYTpLC1cupOhUovP21Vbx7VRSnGVCpQlT\
lCUpNw63wZ8afg58RtUn0T4e/Fn4Z+PNatbCXVbrSPBnjvwt4o1S20uC4tbSbUp9P0TVZ5YbBLu+som\
mZBGsl5EhYNIgPpleDfCL/isvFHxE+Ny/JpXjj/AIR/wJ4A8r5YNW+GHwr1Dxf/AGH4ykx5sd//AG74\
08a/ETU9J1Gyu5tP1Pwff+Fb2GG3u5b7zfea8/MKNDD4qdGgpxjTjDmU5KUo1HBOpBuMIK9OblTfu7x\
b62X2HB+ZZpm+RYfMs1qYetVxdXEOjUw1GpQo1sJHEVIYPEwp1cRipqOLw0aWLjeq7Rrxjb3XKRRRRX\
EfThRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFFFeAftY/HT/AIZf/ZY/aW/aX/4Rb/hOP\
+Gd/wBn/wCMnx0/4Qr+2/8AhGf+Ew/4VJ8OvEfj/wD4Rb/hI/7I1D/hH/7Q/wCEf+yfbvsF99k+1+f9\
jufL8lwD3+ivwk/ZJ/4LKeOvjn+1Z4n/AGZPjR+yBrvwcXQ/h98TvGFj4x+H8P7a3xT1281j4ZD9k+8\
vvDuv/CH4qf8ABOv4YeI/AbXOjftW6DceVq9tba/YweH7DWNR8OWvhDx98NPFXjD9Yv8Aho74e/8AQv\
fHn/xFf9p7/wCdBXZSy7MK8FUo4GtWg/tRpTktr7qLWzT9GfN47jLhDK8RLCZnxVluXYqF70q+OwtGo\
rScXeFSrGStKMou60lFrdMNY/4t98cPCur2nGg/Hv7R4E1/TIOPK+J/gjwj4k8b+EPGUNlF5MMf234b\
eFPG+ka/qMzXmoXP/CIeA9PtYYrDT7uWPxX4carql3+zT+xf8MfD+pX+l6p8UPhn8ILDXdU0K8uINf8\
AD3wz8K/CrSvFnj/WrYabJFe6XYahFpmieDjrdpdWFxoGpfF3SdRs75NVj021u+u+J3xY+HvxE8D634\
VhsfjzoOq3H9m6v4W8Sf8ADJX7T2qf8Ir448LavYeKvAXi/wDsd/hXBHrn9k+NNF0HUv7PuJBZ3/8AZ\
f2O9WS0nmjfA/Yt+G/xP8P/AAw8A+J/jda6DZeNNN+Enw8+G/gXw9osHiG2/wCEI+GGieHtL1CK18Q6\
T4usUu/DXxb1LVZoIPGMdnIun3n/AAr7w5EIEk0kMfpY03h8nni8dTlhsXhqlGEadWE4zrSp08TGhVh\
zxUZxpe0pqcPeShQip3VZRPxCtjIZz4kYXh3hXGUs74dzvCZniK+NwGJw9fD5dRxmNyOtmuAxDw9adb\
DVcw+pYuphsSnSqVMRm1aWFdOWW1Kp9i6VpWl6Fpem6Jomm2GjaLo1hZ6VpGkaVZ2+naXpWl6dbx2mn\
6bpun2kaRWNhBaQwxQwxIscUcSoiqqgC/RRXx7bk3KTcpSd23q23u2+5/SFOnTo06dKlTjSpUoqMYxS\
jGMYq0YxirJRSSSSSSSsgooopFhRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFc/4s8J+Ff\
HvhXxN4F8deGfD/jTwT408P6z4T8Y+DvFmjad4j8K+LPCviPTrnR/EPhnxN4e1i2mtNe8P3+kXl5a3t\
ldQy211bXUkE8bxOynoKKAPmD4KfsRfsX/ALNfirUPHX7Of7In7MHwB8bat4fuvCeqeMfgp8AvhT8K/\
FWpeFb7UdK1i+8M6h4h8C+E7C7vPD82r6Fod1LZSTNbSXOjWk7xmW3hZMD4t/tPeIvht4x8YeBNJ+FA\
8YeIfCvhFfiskS+OYNBtb/4MWOnrb+JvG0l1ceGbj7HrVh4zivNNGjItw9xbJBqK3sfnmzi+vqKNbpq\
zSvdNPX3Xy2aatafK5b80FKK5JSVSGtGdOE1KrR9vBON48zimlKLkrx196ClFNP3XJStLl5ZfDXw4/a\
s8afEX4oeOPDOrfAv4k/C7QvhJoml6940s9Yv/AAB488WX1h4l8DJ4q0qWLwt8Kde1+a8n89jFZWehX\
msajfttWWxtZnS1bmdf/b+0nSLUw2Pwu1nVPGV78W9M8B+GfhTqOvp4A+LPinwRrdvrsmi/Eqz8B/E/\
QdFvNDt7u+0KexjtNYXTbODUPOtNQ1myktLryv0LoqXF8/uy5KXvaauV5TnJNyk5aRi4QilFK0ZP7UV\
TypNwoSp1bV68o00qj93lcMPGnUkoRaX73Ee0xDUuZQTp0Y+7TnKt8kfs7/tAeNPjt4q+Izan8LPEvw\
w8P/D7xN4p+Hl5pHiPX/AOvajH4o8NazBB5uqy+EdYvEtNSl093Zrexu9V02IABNTnkJC/W9FFUkkrJ\
W3e7erbk922kr2iukUlq021reTvdNu22kfsp2Su0rc0rLmldpRTUUUUUUDCiiigAooooAKKKKACiiig\
AooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooAKKKKACiiigAooooA//2Q=='
	$end 'DesignInfo'
$end 'ProjectPreview'
