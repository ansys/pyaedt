$begin 'AnsoftProject'
	Created='Tue Jun 20 11:55:55 2023'
	Product='ElectronicsDesktop'
	FileOwnedByWorkbench=false
	$begin 'Desktop'
		Version(2023, 1)
		InfrastructureVersion(1, 0)
		$begin 'FactoryHeader'
			$begin 'geometry3deditor'
				KernelVersion(2, 0)
				ProjectContainsGeometry3D='0'
			$end 'geometry3deditor'
		$end 'FactoryHeader'
	$end 'Desktop'
	UsesAdvancedFeatures=false
	NextUniqueID=0
	MoveBackwards=false
	$begin 'HFSSEnvironment'
		Version(1, 0)
	$end 'HFSSEnvironment'
	$begin 'PlanarEMEnvironment'
		Version(1, 0)
	$end 'PlanarEMEnvironment'
	$begin 'Q3DEnvironment'
		Version(1, 0)
	$end 'Q3DEnvironment'
	$begin '2DExtractorEnvironment'
		Version(1, 0)
	$end '2DExtractorEnvironment'
	$begin 'NexximEnvironment'
		Version(1, 0)
	$end 'NexximEnvironment'
	$begin 'NexximNetlistEnvironment'
		Version(1, 0)
	$end 'NexximNetlistEnvironment'
	$begin 'EmitEnvironment'
		Version(1, 0)
	$end 'EmitEnvironment'
	$begin 'Maxwell3DEnvironment'
		Version(1, 0)
	$end 'Maxwell3DEnvironment'
	$begin 'Maxwell2DEnvironment'
		Version(1, 0)
	$end 'Maxwell2DEnvironment'
	$begin 'RMxprtEnvironment'
		Version(1, 0)
	$end 'RMxprtEnvironment'
	$begin 'MaxCirEnvironment'
		Version(1, 0)
	$end 'MaxCirEnvironment'
	$begin 'SimplorerEnvironment'
		Version(1, 0)
	$end 'SimplorerEnvironment'
	$begin 'IcepakEnvironment'
		Version(1, 0)
	$end 'IcepakEnvironment'
	$begin 'MechanicalEnvironment'
		Version(1, 0)
	$end 'MechanicalEnvironment'
	$begin 'FilterDesignEnvironment'
	$end 'FilterDesignEnvironment'
	$begin 'SchematicEnvironment'
		Version(1, 0)
	$end 'SchematicEnvironment'
	$begin 'geometry3deditor'
		Version(1, 0)
	$end 'geometry3deditor'
	ReadVersion=11
	$begin 'EDB'
		Path=''
		LastUpdateTimeStamp=1687264794
	$end 'EDB'
	$begin 'DesignMgrEnvironment'
		CompInstCounter=1
		GPortCounter=0
		NetCounter=0
		Alias('Ieee;Simplorer Elements\\Ieee', 'Std;Simplorer Elements\\Std', 'Basic_VHDLAMS;Simplorer Elements\\Basic Elements VHDLAMS\\Basic Elements VHDLAMS', 'Digital_Elements;Simplorer Elements\\Digital Elements\\Digital Elements', 'Transformations;Simplorer Elements\\Tools\\Transformations\\Transformations', 'HEV_VHDLAMS;Simplorer Elements\\HEV VHDLAMS\\HEV VHDLAMS', 'automotive_vda;Simplorer Elements\\VDALibs VHDLAMS\\automotive_vda', 'example_boardnet;Simplorer Elements\\VDALibs VHDLAMS\\example_boardnet', 'example_ecar;Simplorer Elements\\VDALibs VHDLAMS\\example_ecar', 'fundamentals_vda;Simplorer Elements\\VDALibs VHDLAMS\\fundamentals_vda', 'hybrid_emc_vda;Simplorer Elements\\VDALibs VHDLAMS\\hybrid_emc_vda', 'megma;Simplorer Elements\\VDALibs VHDLAMS\\megma', 'modelica_rotational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_rotational', 'modelica_thermal;Simplorer Elements\\VDALibs VHDLAMS\\modelica_thermal', 'modelica_translational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_translational', 'spice2vhd;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd', 'spice2vhd_devices;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd_devices', 'aircraft_electrical_vhdlams;Simplorer Elements\\Aircraft Electrical VHDLAMS\\Aircraft Electrical VHDLAMS', 'power_system_vhdlams;Simplorer Elements\\Power System VHDLAMS\\Power System VHDLAMS')
	$end 'DesignMgrEnvironment'
	$begin 'ProjectDatasets'
		NextUniqueID=0
		MoveBackwards=false
		DatasetType='ProjectDatasetType'
		$begin 'DatasetDefinitions'
		$end 'DatasetDefinitions'
	$end 'ProjectDatasets'
	VariableOrders[0:]
	$begin 'Definitions'
		$begin 'Folders'
			Definitions(1604, 10000, 1, 1, 0, false, false)
			Materials(1604, 9500, 9, 2, 1, false, false)
			'Surface Materials'(1604, 9501, 33503, 3, 1, false, false)
			Scripts(1604, 9502, 33500, 4, 1, false, false)
			Padstacks(1604, 9003, 12, 105, 1, false, false)
			Symbols(1604, 9001, 10, 103, 1, false, false)
			Footprints(1604, 9002, 11, 104, 1, false, false)
			Bondwires(1604, 9006, 12, 108, 1, false, false)
			Components(1604, 9000, 8, 102, 1, false, false)
			Models(1604, 9004, 13, 106, 1, false, false)
			Packages(1604, 9005, 33502, 107, 1, false, false)
		$end 'Folders'
		$begin 'Materials'
			$begin 'copper'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				conductivity='58000000'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'copper'
			$begin 'FR4_epoxy'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal', 'Structural')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=27
						Green=110
						Blue=76
					$end 'MatAppearanceData'
				$end 'AttachedData'
				permittivity='4.4'
				dielectric_loss_tangent='0.02'
				thermal_conductivity='0.294'
				mass_density='1900'
				specific_heat='1150'
				youngs_modulus='11000000000'
				poissons_ratio='0.28'
				thermal_expansion_coefficient='1.5e-05'
				ModTime=1499970477
				Library='Materials'
				LibLocation='Project'
				ModSinceLib=true
			$end 'FR4_epoxy'
			$begin 'Megtron4'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3.77'
				dielectric_loss_tangent='0.005'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Megtron4'
			$begin 'Megtron4_2'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3.47'
				dielectric_loss_tangent='0.006'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Megtron4_2'
			$begin 'Megtron4_3'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='4.2'
				dielectric_loss_tangent='0.005'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Megtron4_3'
			$begin 'Solder Resist'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3'
				dielectric_loss_tangent='0'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Solder Resist'
			$begin 'pec'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=247
						Green=242
						Blue=232
					$end 'MatAppearanceData'
				$end 'AttachedData'
				conductivity='1e+30'
				ModTime=1499970477
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'pec'
		$end 'Materials'
		$begin 'SurfaceMaterials'
		$end 'SurfaceMaterials'
		$begin 'Scripts'
		$end 'Scripts'
		$begin 'Symbols'
			$begin 'CAPC0603X33X15LL03T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'COIL-1008CS_V'
			$begin 'main'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('V1', -0.00508, 0.05334, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, 'V1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.053975, 0, 4, 5, false, 'Arial', 0, 'V1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.054856944444448, 0.00185672514620626, 0.00176388888889594, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('I1', 0.00508, 0.05334, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, 'I1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.053975, 0, 4, 5, false, 'Arial', 0, 'I1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.054856944444448, 0.00129970760234438, 0.00176388888889594, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('I2', -0.00508, 0.0508, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, 'I2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.051435, 0, 4, 5, false, 'Arial', 0, 'I2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.052316944444448, 0.00129970760234438, 0.00176388888889594, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('I3', 0.00508, 0.0508, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, 'I3', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.051435, 0, 4, 5, false, 'Arial', 0, 'I3', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.052316944444448, 0.00129970760234438, 0.00176388888889594, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('I4', -0.00508, 0.04826, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, 'I4', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.048895, 0, 4, 5, false, 'Arial', 0, 'I4', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.049776944444448, 0.00129970760234438, 0.00176388888889594, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0.00127, 0.00508, 0.10922, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0.05334, 0.000423333333333334, 0.000423333333333333, 0, 0, 0)
				$end 'Graphics'
			$end 'main'
			$begin 'MURA-BLM15-CHIP-2_V'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'WE-Coil-PD4-S'
		$end 'Symbols'
		$begin 'DefInfo'
			CAPC0603X33X15LL03T05(1002, 0, 0, 2, '', 1687254942, '', 'CAPC0603X33X15LL03T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X05N(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X05N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X33X10LL5(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X33X10LL5', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X10LL05(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X10LL05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X23ML05T8(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X23ML05T8', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X25LL05T10(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X25LL05T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X25ML05T10(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X25ML05T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X25NL05T10(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X25NL05T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1608X08N(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1608X08N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1608X90X35ML10T15(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1608X90X35ML10T15', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC2012X12N(1002, 0, 0, 2, '', 1687254942, '', 'CAPC2012X12N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC2013X100X20NL20(1002, 0, 0, 2, '', 1687254942, '', 'CAPC2013X100X20NL20', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC3216X180X20ML20(1002, 0, 0, 2, '', 1687254942, '', 'CAPC3216X180X20ML20', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC3216X180X55ML20T25(1002, 0, 0, 2, '', 1687254942, '', 'CAPC3216X180X55ML20T25', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC3216X190X55ML30T25(1002, 0, 0, 2, '', 1687254942, '', 'CAPC3216X190X55ML30T25', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPMP7343X31N(1002, 0, 0, 2, '', 1687254942, '', 'CAPMP7343X31N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'COIL-1008CS_V'(1002, 0, 0, 2, '', 1687254942, '', 'COIL-1008CS_V', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'MURA-BLM15-CHIP-2_V'(1002, 0, 0, 2, '', 1687254942, '', 'MURA-BLM15-CHIP-2_V', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'MURA-BLM15AG221SN1x_V'(1002, 0, 0, 2, '', 1687254942, '', 'MURA-BLM15AG221SN1x_V', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X35X25NL8T10(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X35X25NL8T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25LL05T05(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25LL05T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25ML05T05(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25ML05T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25NL05T05(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25NL05T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25NL5T10(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25NL5T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1608X05N(1002, 0, 0, 2, '', 1687254942, '', 'RESC1608X05N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'SMD-0603'(1002, 0, 0, 2, '', 1687254942, '', 'SMD-0603', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'WE-Coil-744301047'(1002, 0, 0, 2, '', 1687254942, '', 'WE-Coil-744301047', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'WE-Coil-PD4-S'(1002, 0, 0, 2, '', 1687254942, '', 'WE-Coil-PD4-S', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			main(1002, 0, 16, 5, '', 1687254942, '', 'main', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
		$end 'DefInfo'
		$begin 'Compdefs'
			$begin 'CAPC0603X33X15LL03T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 0, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 1, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 2, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 3, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 4, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 5, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 6, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 7, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 8, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 9, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 10, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 11, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 12, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 13, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 14, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 15, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 16, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 17, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 18, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 19, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 20, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 21, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 22, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 23, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 24, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 25, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 26, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 27, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 28, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 29, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 30, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 31, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 32, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 33, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'COIL-1008CS_V'
			$begin 'MURA-BLM15-CHIP-2_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 34, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 35, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 36, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 37, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 38, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 39, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 40, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 41, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 42, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 43, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 44, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 45, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 46, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 47, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 48, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 49, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 50, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 51, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 52, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 53, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 54, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 55, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'WE-Coil-PD4-S'
			$begin 'main'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('V1', 'V1', 'A', false, 84, 1, '', 'Electrical', '0')
				Terminal('I1', 'I1', 'A', false, 85, 1, '', 'Electrical', '0')
				Terminal('I2', 'I2', 'A', false, 86, 1, '', 'Electrical', '0')
				Terminal('I3', 'I3', 'A', false, 87, 1, '', 'Electrical', '0')
				Terminal('I4', 'I4', 'A', false, 88, 1, '', 'Electrical', '0')
				$begin 'Properties'
					TextProp('Representation', 'SD', '', 'main')
				$end 'Properties'
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'main'
		$end 'Compdefs'
	$end 'Definitions'
	DesignIDServer=2
	MoveBackwards=false
	$begin 'PlanarEMCircuit'
		RepRewriteV2=true
		Name='main'
		DesignID=0
		$begin 'Circuit'
			ComponentName='main'
			AutoFP=''
			$begin 'DesignDatasets'
				NextUniqueID=0
				MoveBackwards=false
				DatasetType='DesignDatasetType'
				$begin 'DatasetDefinitions'
				$end 'DatasetDefinitions'
			$end 'DesignDatasets'
			VariableOrders[0:]
			$begin 'IPort'
				PortName='I1'
				Public=true
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'IPort'
				PortName='I2'
				Public=true
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'IPort'
				PortName='I3'
				Public=true
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'IPort'
				PortName='I4'
				Public=true
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'IPort'
				PortName='V1'
				Public=true
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'IPort'
				PortName='InternalPort1'
				Public=false
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'IPort'
				PortName='InternalPort2'
				Public=false
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'IPort'
				PortName='InternalPort3'
				Public=false
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'IPort'
				PortName='InternalPort4'
				Public=false
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'IPort'
				PortName='InternalPort5'
				Public=false
				Connectible=true
				UnconnectedAction=1
				PortValue=''
				Domain(0, -1, 2, '')
			$end 'IPort'
			$begin 'Net'
				NetName='+VREFDDR4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_AVDDL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_AVDLL_PLL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_DVDDL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.8V_DVDDH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='12V-In'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1V0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='2V5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='3.3V_AVDDH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='5V'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='A10_GNDSENSE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AVCC_1V3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLOCK_I2C_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLOCK_I2C_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ACT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BG0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CAS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CKE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CLK_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CLK_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CSN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ20'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ21'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ22'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ23'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ24'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ25'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ26'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ27'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ28'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ29'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ30'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ31'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ32'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ33'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ34'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ35'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ36'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ37'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ38'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ39'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ40'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ41'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ42'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ43'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ44'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ45'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ47'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ48'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ49'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ50'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ51'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ52'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ53'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ54'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ55'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ56'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ57'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ58'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ59'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ60'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ61'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ62'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ63'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS4_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS4_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS5_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS5_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS6_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS6_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS7_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS7_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ODT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_PAR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_RAS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_RESETN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_WEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_3V3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_GTX_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_MDC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_MDIO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RX_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RX_DV'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TX_EN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GND_DP'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='I1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInterfacePorts='I1'
			$end 'Net'
			$begin 'Net'
				NetName='I2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInterfacePorts='I2'
			$end 'Net'
			$begin 'Net'
				NetName='I3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInterfacePorts='I3'
			$end 'Net'
			$begin 'Net'
				NetName='I4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInterfacePorts='I4'
			$end 'Net'
			$begin 'Net'
				NetName='InternalPort1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInternalPorts='InternalPort1'
			$end 'Net'
			$begin 'Net'
				NetName='InternalPort2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInternalPorts='InternalPort2'
			$end 'Net'
			$begin 'Net'
				NetName='InternalPort3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInternalPorts='InternalPort3'
			$end 'Net'
			$begin 'Net'
				NetName='InternalPort4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInternalPorts='InternalPort4'
			$end 'Net'
			$begin 'Net'
				NetName='InternalPort5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInternalPorts='InternalPort5'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TCK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TDI'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TDO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TMS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TRST'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH01_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH01_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH02_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH02_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH03_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH03_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH04_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH04_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH05_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH05_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH06_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH06_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH07_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH07_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH08_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH08_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH09_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH09_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH10_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH10_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH11_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH11_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH12_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH12_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC10_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC10_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC177_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC178_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC179_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC180_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC18_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC19_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC19_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC25_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC26_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC26_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC271_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC291_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC33_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC34_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC34_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC35_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC42_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC43_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC50_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC50_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC9_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetD3_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC2_5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ3_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR100_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR102_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR104_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR105_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR106_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR108_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR113_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR114_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR115_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR116_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR116_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR117_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR119_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR11_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR120_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR121_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR122_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR123_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR124_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR12_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR13_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR1_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR22_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR24_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR25_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR26_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR34_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR65_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR66_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR82_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR83_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR8_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR99_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU13_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU13_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AP13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AV11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AW11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AW13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU9_46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_CLKREQ_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_REFCLK_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_REFCLK_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RST_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_SMB_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_SMB_DATA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_USB_D_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_USB_D_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_W_DISABLE_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_WAKE_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PDEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PLL_1V8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK0_FMCB_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK0_FMCB_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK_DP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK_DP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA__Mod_ABS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RS0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RS1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Rx_LOS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Tx_Disable'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Tx_Fault'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_TX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_TX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_VCCR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_VCCT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD4_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD4_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_D_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_D_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSTX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSTX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_VBUS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='V1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
				NetInterfacePorts='V1'
			$end 'Net'
			$begin 'Net'
				NetName='VDD_DDR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
		$end 'Circuit'
		$begin 'Layout'
			BlackBox=false
			DefUnits='mm'
			NIdx=6041
			ActLyr='1_Top'
			Tol(1e-08, 1e-08, 1e-12)
			$begin 'HfssExportInfo'
				ScriptFileName=''
				HfssFileName=''
				Version=2
				ExtentType='PolygonExtent'
				BasePolygon='poly_5949'
				BasePolygonEDBUId=5949
				DielExtentType='BboxExtent'
				DielBasePolygon=''
				DielBasePolygonEDBUId=-1
				DielExt(Ext='0', Dim=false)
				HonorUserDiel=true
				TruncAtGnd=false
				AirHorExt(Ext='0.15', Dim=false)
				AirPosZExt(Ext='0.15', Dim=false)
				AirNegZExt(Ext='0.15', Dim=false)
				SyncZExt=true
				OpenRegionType='Radiation'
				UseRadBound=true
				PMLVisible=false
				OperFreq='5GHz'
				RadLvl=0
				UseStackupForZExtFact=false
				Smooth=true
			$end 'HfssExportInfo'
		$end 'Layout'
		$begin 'Rule Set'
			$begin 'Data'
			$end 'Data'
			$begin 'DRCSolutionMgr'
			$end 'DRCSolutionMgr'
		$end 'Rule Set'
		$begin 'Workflow'
			WorkflowName=''
			SpecName=''
			TemplateName=''
			LibLoc=-2
		$end 'Workflow'
		$begin 'Port'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Port'
		$begin 'Boundary'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Boundary'
		$begin 'Cavity'
			$begin 'Data'
			$end 'Data'
		$end 'Cavity'
		$begin 'Via'
			$begin 'Data'
			$end 'Data'
		$end 'Via'
		$begin 'LayoutVia'
			$begin 'Data'
			$end 'Data'
		$end 'LayoutVia'
		$begin 'Source'
			$begin 'Data'
				$begin 'I1'
					DataId='Source1'
					DCIRPort='I1'
					Amp='1A'
					Imp='50000000ohm'
				$end 'I1'
				$begin 'I2'
					DataId='Source2'
					DCIRPort='I2'
					Amp='1A'
					Imp='50000000ohm'
				$end 'I2'
				$begin 'I3'
					DataId='Source3'
					DCIRPort='I3'
					Amp='1A'
					Imp='50000000ohm'
				$end 'I3'
				$begin 'I4'
					DataId='Source4'
					DCIRPort='I4'
					Amp='1A'
					Imp='50000000ohm'
				$end 'I4'
				$begin 'V1'
					DataId='Source0'
					DCIRPort='V1'
					Amp='1V'
					Imp='1e-06ohm'
				$end 'V1'
			$end 'Data'
		$end 'Source'
		$begin 'Voltage Probe'
			$begin 'Data'
			$end 'Data'
		$end 'Voltage Probe'
		$begin 'DC Terminal'
			$begin 'Data'
			$end 'Data'
		$end 'DC Terminal'
		$begin 'CircuitSources'
			$begin 'Data'
			$end 'Data'
		$end 'CircuitSources'
		$begin 'NexximPorts'
			$begin 'Data'
			$end 'Data'
			$begin 'DiffPairs'
			$end 'DiffPairs'
		$end 'NexximPorts'
		$begin 'SortOrder'
		$end 'SortOrder'
		$begin 'NexximMultiComponentContainers'
			$begin 'Data'
			$end 'Data'
		$end 'NexximMultiComponentContainers'
		$begin 'ComponentConfigurationData'
			$begin 'EnabledPorts'
			$end 'EnabledPorts'
			$begin 'EnabledMultipleComponents'
			$end 'EnabledMultipleComponents'
			$begin 'EnabledAnalyses'
			$end 'EnabledAnalyses'
		$end 'ComponentConfigurationData'
		$begin 'Properties'
		$end 'Properties'
		$begin 'CustomSimSetups'
			$begin 'Data'
			$end 'Data'
		$end 'CustomSimSetups'
		$begin 'RadSetup'
			$begin 'Data'
			$end 'Data'
		$end 'RadSetup'
		$begin 'Setup'
			$begin 'Data'
				$begin 'SIwaveDCIR1'
					DataId='Setup1'
					$begin 'Properties'
						Enable='true'
					$end 'Properties'
					CustomSetup=false
					SimSetupID=5
					SolveSetupType='SIwaveDCIR'
					SolutionID=7
				$end 'SIwaveDCIR1'
			$end 'Data'
		$end 'Setup'
		$begin 'AnalysisOptionBlocks'
		$end 'AnalysisOptionBlocks'
		$begin 'EM properties'
			$begin 'Data'
			$end 'Data'
		$end 'EM properties'
		$begin 'OutputVariable'
			NextUniqueID=0
			MoveBackwards=false
		$end 'OutputVariable'
		$begin 'Optimetrics'
			$begin 'OptimetricsSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'OptimetricsSetups'
		$end 'Optimetrics'
		$begin 'FieldsReporter'
			$begin 'FieldsCalculator'
				Line_Discretization=1000
			$end 'FieldsCalculator'
			$begin 'PlotDefaults'
				Default_SolutionId=7
				Default_PlotFolder='Automatic'
			$end 'PlotDefaults'
			$begin 'FieldsPlotManagerID'
				NextUniqueID=0
				MoveBackwards=false
				NumQuantityType=0
				NumPlots=0
			$end 'FieldsPlotManagerID'
			$begin 'Report3dInGeomWnd'
				Report3dNum=0
			$end 'Report3dInGeomWnd'
			$begin 'Report2dInGeomWnd'
				Report2dNum=0
			$end 'Report2dInGeomWnd'
			$begin 'AntennaParametersInGeomWnd'
				AntennaParametersNum=0
			$end 'AntennaParametersInGeomWnd'
			AntennaParametersPlotTablesOrder()
			$begin 'EntitySelectionCache'
			$end 'EntitySelectionCache'
		$end 'FieldsReporter'
		$begin 'SolutionManager'
			$begin 'SimDataExtractors'
				$begin 'ID Map'
					$begin 'Setup'
						N='SIwaveDCIR1'
						I=5
						Soln(N='SIwaveDCIR1', I=7)
					$end 'Setup'
				$end 'ID Map'
				$begin 'SimSetup'
					TypeName='BaseSetup'
					ID=5
					Name='SIwaveDCIR1'
					$begin 'Solution'
						ID=7
						Name='SIwaveDCIR1'
						ImportedType=3
						$begin 'SimDataExtractor'
							$begin 'QuantityIDs'
								NextUniqueID=0
								MoveBackwards=false
								IDMap()
							$end 'QuantityIDs'
						$end 'SimDataExtractor'
					$end 'Solution'
				$end 'SimSetup'
				$begin 'Version ID Map'
					V=2
					$begin 'Setup'
						N='SIwaveDCIR1'
						V=8
						Soln(N='SIwaveDCIR1', V=8)
					$end 'Setup'
				$end 'Version ID Map'
			$end 'SimDataExtractors'
		$end 'SolutionManager'
		$begin 'InterfaceOptions'
			SchematicEnabled=false
			SaveBeforeSolving=true
		$end 'InterfaceOptions'
		$begin 'AdvancedSettings'
			ComputeBothEvenAndOddCPWModes=false
			CausalMaterials=true
			MeshingMethod='Phi'
			EnableDesignIntersectionCheck=true
			UseAlternativeMeshMethodsAsFallBack=true
			CircuitSparamDefinition=false
			CircuitIntegrationType='FFT'
			BroadbandFreqOption='AutoMaxFreq'
			BroadbandMaxNumFreq=5
			SaveADP=false
			UseAdvancedDCExtrap=false
			ModeOption='General mode'
			PhiMesherDeltaZRatio=100000
			SpiceType='TouchStone1.0'
			EnforcePassivity=false
			EnforceCausality=false
			UseCommonGround=true
			ShowGammaComments=false
			Renormalize=true
			RenormImpedance=50
			FittingError=0.5
			MaxPoles=10000
			PassivityType='IteratedFittingOfPV'
			ColumnFittingType='Matrix'
			SSFittingType='FastFit'
			RelativeErrorToleranc=false
			EnsureAccurateZfit=true
			TouchstoneFormat='MA'
			TouchstoneUnits='GHz'
			TouchStonePrecision=15
			ExportAfterSolve=false
			ExportDir=''
		$end 'AdvancedSettings'
		$begin 'CoSimOptions'
			Override=false
			Setup=''
			OverrideSweep=false
			Sweep=''
			FrequencySweepType=0
			Interpolate=false
			YMatrix=true
			AutoAlignPorts=false
			Simulator=1
			InterpAlg='auto'
			Renormalize=false
			RenormImpedance=50
		$end 'CoSimOptions'
		$begin 'TemperatureData'
			IncludeTempDependence=false
			EnableFeedback=false
			Temperature='22cel'
		$end 'TemperatureData'
		$begin 'UserDefinedSolutionMgr'
			NextUniqueID=1000000
			MoveBackwards=false
		$end 'UserDefinedSolutionMgr'
		$begin 'DatasetSolutionMgr'
			NextUniqueID=2000000
			MoveBackwards=false
		$end 'DatasetSolutionMgr'
		Notes=$begin_cdata$ $end_cdata$
		$begin 'AnimationSetups'
		$end 'AnimationSetups'
		CacheHeaderFile='HDR5ABE7300416872647946.tmp'
	$end 'PlanarEMCircuit'
	$begin 'DataInstances'
		DesignEditor='TopLevel'
		Refdes('0', 'U1')
		$begin 'CompInstances'
			$begin 'Compinst'
				ID='0'
				Status='Status'
				CompName='main'
				GatesInUse()
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '0')
				$end 'Properties'
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'OHD', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'OHD', '', 'DefaultNetlist', 0)
				$end 'Parameters'
			$end 'Compinst'
		$end 'CompInstances'
		$begin 'Instance'
			DesignEditor='main'
			ID='0'
			$begin 'PlanarEMItem'
				Editor3D=true
				$begin 'PostProcessing'
					$begin 'Fields'
						$begin 'Items'
						$end 'Items'
					$end 'Fields'
					DesignInstanceID=1
					$begin 'WindowPosition'
						$begin 'EditorWindow'
							Circuit(Layout(View(WindowPos(3, -1, -1, -8, -31, 0, 0, 136, 50), Extent(-0.880303025245667, -1, 0.880303025245667, 1, 10827.8112673769, 10822.4243630925, -0.0616246536374092, 0.0865531489253044, 0.202903427183628, 0.0969283729791641, 1), ViewingXfm(-1.1116201877594, 0.633532047271729, -0.414779305458069, 0.418892025947571, 313.394195556641, 321.303497314453, 8.60090065002441, 0, 0, 0, 0, 8.60090065002441, 0, 0, 0, 0, 8.60090065002441, 0, -0.581592679023743, -0.325543016195297, -317.356353759766, 1))), Layout())
						$end 'EditorWindow'
					$end 'WindowPosition'
					$begin 'ReportSetup'
						$begin 'ReportManager'
							$begin 'Reports'
							$end 'Reports'
							NextUniqueID=0
							MoveBackwards=false
							$begin 'NextVersID'
								NextUniqueID=0
								MoveBackwards=false
							$end 'NextVersID'
						$end 'ReportManager'
						$begin 'Reports'
						$end 'Reports'
						$begin 'ReportsWindowInfoList'
						$end 'ReportsWindowInfoList'
					$end 'ReportSetup'
				$end 'PostProcessing'
				$begin 'Properties'
				$end 'Properties'
				$begin 'UserDefinedDocument'
					$begin 'Data'
					$end 'Data'
				$end 'UserDefinedDocument'
			$end 'PlanarEMItem'
			$begin 'TopLayout'
				DefaultUnits='mm'
				DefaultAngleUnits='deg'
				MajorSize='10mm'
				MinorSize='1mm'
				PixelSnapTolerance=20
				SnapAcrossHierarchy=true
				SnapTargetVertex_on=true
				SnapTargetEdgeCenter_on=true
				SnapTargetObjCenter_on=true
				SnapTargetEdge_on=false
				SnapTargetElecConnection_on=true
				SnapTargetIntersection_on=false
				SnapTargetGrid_on=true
				SnapSourceVertex_on=true
				SnapSourceEdgeCenter_on=true
				SnapSourceObjCenter_on=true
				SnapSourceEdge_on=false
				SnapSourceElecConnection_on=true
				ConstrainToGrid=false
				DirectionConstraint=0
				defaultholesize='25mil'
				anglesnap='5deg'
				$begin 'TextStyles'
					TextStyle(N='<DefaultAnnotation>', F='Arial', Hght=12, Scale=false)
					TextStyle(N='<DefaultPlotter>', Plot=true, F='RomanSimplex', Hght=5, HghtUnt='mm')
					TextStyle(N='<DefaultMeasure>', Plot=true, F='RomanSimplex', Hght=1, HghtUnt='mm')
				$end 'TextStyles'
				$begin 'TraceStyles'
					TraceStyle(name='Half Grid', size='0.5mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='1 Grid', size='1mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='2 Grids', size='2mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='5 Grids', size='5mm', bendStyle=0, capStyle=0, capStyle=0)
				$end 'TraceStyles'
				'current via style'='PlanarEMVia'
				'current pin style'=''
				MajorColor=16772075
				MinorColor=16774645
				ShowGrid=true
				PageExtent(-0.1, -0.1, 0.1, 0.1)
				'background color'=16777215
				DefaultToSketchMode=false
				fillMode=true
				DocVisibilityFlag=962
				FastViewTransforms=true
				StartingHierarchyLevel=0
				EndingHierarchyLevel=-1
				SingleLevelView=false
				'show connection points'=false
				'draw rats'=false
				'display vertex labels'=false
				ColorByNet=false
				'display package graphics'=false
				'rectangle description'=0
				snaptoport=true
				autoplacecomp=false
				'sym footprint scaling'=4.1163018385
				AutoScale=true
				'measure display digits'=3
				'display measure units'=false
				SuppressPads=true
				AntiPadsOption=0
				TextIsVisible=true
				'primary selection color'=255
				'secondary selection color'=3289780
				'preview selection'=false
				AllowDragOnFirstClick=false
				PinConnectivityPopup=false
				CreatePortsOnComp=false
				OptionUseNamingConvention_PadPort=false
				OptionNamingConvention_PadPort='$REFDES_$PINNAME_$NETNAME'
				useFixedDrawingResolution=false
				DrawingResolution='0.002mm'
				$begin 'ViewConfigs'
					ViewConfigsCurrent=''
				$end 'ViewConfigs'
				currentTextStyle=0
				currentTraceStyle=0
				prevBounds(-0.880303025245667, -1, 0.880303025245667, 1)
				prevMapFactor(10827.8112673769, 10822.4243630925)
				prevOrigin(-0.0616246536374092, 0.0865531489253044)
				prevViewExtent(0.202903427183628, 0.0969283729791641)
				prevZoomScale=1
				$begin 'Animation'
					LabelColor(R=230, G=230, B=230)
					FontName='Arial'
					FontHeight=24
					FontWeight=400
				$end 'Animation'
			$end 'TopLayout'
		$end 'Instance'
		$begin 'SODInfo'
			$begin 'CAPC0603X33X15LL03T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'COIL-1008CS_V'
			$begin 'MURA-BLM15-CHIP-2_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'WE-Coil-PD4-S'
			$begin 'main'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'main'
		$end 'SODInfo'
	$end 'DataInstances'
	$begin 'WBSystemIDToDesignInstanceIDMap'
	$end 'WBSystemIDToDesignInstanceIDMap'
	$begin 'WBSysIDSysDetails'
	$end 'WBSysIDSysDetails'
	$begin 'WBConnIDConnDetails'
	$end 'WBConnIDConnDetails'
	$begin 'WBMaterialGuidDetails'
		WBMaterialGuidMap()
	$end 'WBMaterialGuidDetails'
	$begin 'MinervaProjectSettingsBlk'
		MinervaRemoteFilePath=''
		FolderContainerString=''
	$end 'MinervaProjectSettingsBlk'
$end 'AnsoftProject'
$begin 'AllReferencedFilesForProject'
$end 'AllReferencedFilesForProject'
$begin 'ProjectPreview'
	IsEncrypted=false
	Thumbnail64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCABgAGADASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+5G11CCK51bdHfHzNQR18vTNSmwF0zToSHENo3\
lNviYhWwxQrIAUdGZqajbpq18xjvyDYabH8ul6m7bo7nVixKpZkhDvXa2NrYO0na2L9j/x9az/2Eov/\
AEz6VRF/yGL7/sG6V/6VazX20nS/e3hL+FT+0v8Ap1b7H/D+Rza9/wCvvKF5qNu9xpbCO/Ahv5JHD6X\
qcbFTpmoxARJJZgzvulUlUDMFDORsR2U1TUbebTNRiSO/DS2F5Gpl0vU4Iwz28igyTTWapCmSMs7Kqj\
JYgAmr99/x9aN/2Epf/TPqtGs/8gfVf+wbff8ApLLRB0ufB+5K+lveWn7yW/ua6+nbzEr6/wBdEH9q2\
v8Azy1L/wAE2sf/ACDVDTtRt4reRWjvyTf6pIDHpepzLtm1O8lQF4rNgHCuAyk7kYFHCurKOhrN0r/j\
1l/7CWs/+ni+rNOj7Gp+7lbmh9tdp/3P6/N63Xz/AEKEeo241O8lMd/tew06MAaXqZkDRXGqMxeEWe+\
NCJk2syhXIYIWKOFLzUbd7jS2Ed+BDfySOH0vU42KnTNRiAiSSzBnfdKpKoGYKGcjYjst+L/kMX3/AG\
DdK/8ASrWa/Jf/AILt2Go6r/wTA/aB0vSNL1XXNW1LXvgXYaXouhaXqGua5rGo3nx9+GVvZaXo2iaTb\
TXWsarcXMkUVva20MtxcTTJDDHJI6qdV7OVZRjSnOcqeijJNu9HRJcl3J7Lu+nQ5sbiHhMHisU4e0+r\
U51OW9ubki5Wvra9rXs7X2P1Z1TUbebTNRiSO/DS2F5Gpl0vU4Iwz28igyTTWapCmSMs7KqjJYgAmr/\
9q2v/ADy1L/wTax/8g1/FF8c9B/4Il6H+03+ypof7LujeHdHt9H8cfHDSv2htH+LmnftIaf4T0tdP+E\
Xiiz8Jab4+0/8AanhTSLF4PF8N/FFDMitFq8VkkirqC6cB9M/Z/wDgl9/zw/YJ/wC/X7PX/wATXvcKZ\
JlvFOCx9aec0cnllmLnhnGvUpr2r+r4as6tGTceeknW9i5csWq9KtDXkufh/H3jeuBczy7Lo8LVOJo5\
hg4YtV8vxPtqEFPEYih7KU/q/wDEX1f2jX8lWm9b6/1a6dqNvFbyK0d+Sb/VJAY9L1OZds2p3kqAvFZ\
sA4VwGUncjAo4V1ZQR6jbjU7yUx3+17DTowBpepmQNFcaozF4RZ740ImTazKFchghYo4X/Pv/AOCov7\
Y/7Mv7HWi/BvU/2Zf2af2HPj83jjVPGNv45ktfhl8P/Hmm+D7Tw83g6fSFvrv4f6pbf2FfapDrGvxWg\
vFkWd9MlniDCwmt7n47+Ev/AAVl+GHibWofBevf8EzP2HPFHiLVzf6roHi8eNPhT+zR8OLvw9Y2aCaG\
TW/2gPhm1mt/Fq1lrcHnT6taC6mjFnaWTzQ+bc71so4ep5xjMpnxGnWjKMJVYUZ1cO6lVUatOnCpS5+\
ac/awjGMYtuSnG3utnv8AD/HPH3E/DWD4qyXwpq1spxka0ouvnOW4KcaeHqzo1alRY54aFOKnSqW55p\
yhCU4xcE2f6a1rpmmzXOrCbT7GURagiR+ZaQP5aPpmnTsibozsUzzTOQOC8rMeWJLU0vTH1a+V9OsHU\
WGmyhWs7dlEktzqwlkAMf32Ece49TsGc4FOtbSd7nVtup30OzUEVjHHpp80nTNOkDv52nvhgjrGNu1d\
kKkguXd2pZ3DatfAapfofsGmvuWPTCxV7nVgsR36cRsXa23jcfMO5m+Xb865T/e/7Vb91DrU0/h66R6\
/rqfrNlp7v5BeaXpkdxpaR6dYIs9/JFMqWduqzRjTNRmEcoEeJEE0MT4ORuiVuqgg1TS9Mg0zUZodOs\
IZobC8lilis7eOSKSO3keOSORIwUdWAIIIIIyOaLyzuFuNLB1S/kMl/IiO8emBoGGmajIZYhHpyguVR\
kO8Ou2ZiFDhHU1SzuI9M1GR9Uv51SwvHaGWPTBHMq28hMUhh05HCMAQdjq2CdrKcEEZT58L/tV72ur1\
Pe/eS/u/LW23YO+l/wDhkX/7G0f/AKBWm/8AgDa//GqoadpemTW8jy6dYSsL/VIg0lnbuwjg1O8hhjB\
aMkIkMcaKOiqgUYAAq/8AYbr/AKDOpf8AfrR//lVVDTrO4e3kK6pfwgX+qIUjj0wqWj1O8jeUmXTmO9\
2Uu2CFDSEIqJtRc1Op7Kf+2a80db1NNJ6fDfX9NegdVp/WgR6Xph1O8hOnWBhjsNOljiNnbmNJJrjVE\
lkSMx4V2WCEMQMsIVByFGPg7/gppYWNp+ywj2tnaWzyftG/sYxu9vbwws8f/DX3wPk8t2jQFk8yONsH\
jdGp6gV94x2dwdTvIxql+GWw05zMI9M8yRXuNUCxODpxQIhjcrtRWJnbezAIE+Dv+CmlvND+ywjSX93\
dhv2jf2MVCXCWKrG3/DX3wPfzENrZxEvtVl+Ysu2Rvl3bWX1MplP+2csTxPMvaUfdvPXSOusba76v8T\
5zjH/kkeKdLf8ACdjf/Uaofxfa3/wSQ8U/tceJfjT8ZfAP7X2h6TpnxX/bD+Ouqatf2mifEHXtf+EPh\
XwR8Rv2gPDlz4T8DXHh348w+H/GcWteJpvAM+qWeraLp15ZW2lWt3omt6bBZ6hofiv1r9l39mH4L/s4\
fG79p34k/FzwPZ+J/hj4h8N/tRfEj412nxV/YZ+J3h7QPgFb/so/GWDwn8KfGXgX4veIdDl8HfFyf4t\
/B3xT8QPiJrGlfDrRLLTdMutCg03w9oukaPaWWiw/sL+yz4isNd8DfEG1sbfXYJPDP7Sv7VXh3UW1nw\
v4l8OW9zfx/tE/ErV2uPD934h0m1i8WaF9k1i0RdU0p73TGuobqxW7N7Y3tvb+ffB/9r+9+KH7RfjL4\
G6r8Ir/AMDaImhfFvxR8G/H158UPhX4m1X4qeGf2e/jlP8Asz/GnxF4h+EvhjxJP4j+DuhRfHGy1jS/\
Cd3rdqbfxhZ+FdbvrSSxm0m608ftmX8M8MU6OQZhalhcwzh06klKmq0MVXeHlKdOpGV4xipupUlFOn+\
891ONoRX8MrxR8T87yXj7hzHZX/bnDPD2AhRr+zjgssxOX4CGPw0qVeNWlhqdXE4i9DCqlKVPEVIQpS\
xLpzpvGTq/yc/DXxf8Df8Ago18dPj14j8c/s0/FXwX8PfCn7PreMpP2e/2JLaPx38RPEfjTTvj54O+H\
3gzxr8NPBvibw1/Zmg32lfC/wCJfh+18UwaXFpdpq114Qv/ABWbBF1PUNJtsbwx8KP+Cm3ww8GWP7GP\
hfwXqM0H7ROk+HPjro3wHl+F/gPxp4l+Cun/ABx8U+K/hRD8TPHfiDVfhjJcfATWbTRfh80F1PY3GkQ\
eFo/iFBezz+HvEEWoWEHnn/BKD4trB+0T8K/gFN4Z+DulW/jjxrqniCy8e+Jrn/hAvG/ibx34P1n4Qf\
Hj4KfCTVPi49pqY0bwLqfx6/Zg+Fmlw2q+HdbvBH8TPEkGk2M+s6vp01j+yX7S37MP7SX7VX7fX7Ujf\
BqX4X/HP4I+NfC/wx+Gfjq/8ffEbW9c+AfgO0+G+hXmp3n7NPxCuPh74r0fxf8ADrx/p37Q/wANrTxd\
qGl+A7y/vtOn8baBdeKLWx03xHq1rqX5tHJcNmWWRx+EwmJeY4jGU8NVWBj7D2ka8YVq9SpChCzowp0\
40pzjTqKLnOc6co6P+uOM8zocAcX5hwfjcLlmXcF4TAYfOMI84f8AaWHwtLL8VhMvw6wsMViFGOMxE3\
jK0KFerTxOJWFwuDji6NCd6f8AoTWsmpC51bybSxcnUEMnmahPFscaZpwVU26Y/mKYBCxJ2kO7IFIQS\
O1JNTGrX2yzsGb7BpoIbUbhF8sXOreU4YaW2XJMm5cYXaMM247XWuoQRXOrbo74+ZqCOvl6ZqU2Auma\
dCQ4htG8pt8TEK2GKFZACjozNTUbdNWvmMd+QbDTY/l0vU3bdHc6sWJVLMkId67WxtbB2k7Wx8Y4z/e\
/7Lf91DpU1/h6aS6fpqfqN1p735BeSambjSzJZ2CsL+QwhNRuHWST+zNRBSVjpamFPJMrbgHJZFTaAx\
dDVJNTOmaiJrOwjhNheCWSLUbiaRIzbyCR44n0tBK4XJCl0DEYLKDkF5qNu9xpbCO/Ahv5JHD6XqcbF\
TpmoxARJJZgzvulUlUDMFDORsR2U1TUbebTNRiSO/DS2F5Gpl0vU4Iwz28igyTTWapCmSMs7KqjJYgA\
miMZ8+F/2W1rXdqnu/vJf3vnrffsHfW3/DIv+brH/Pjpv/g1uv8A5TVQ06TUxbyCKzsHX7fqhJk1G4i\
YSHU7wzIFXS3BRZjIqtkF1UOVQsUW/wD2ra/88tS/8E2sf/INUNO1G3it5FaO/JN/qkgMel6nMu2bU7\
yVAXis2AcK4DKTuRgUcK6sozUKnsp/7HrzR0tU10nr8V9P116B1Wv9aBHJqf8Aad4RZ2BmNhpwkjOo3\
AjWMXGqGJ0lGlku7MZgylFCiNSGcuQny1+2z8H/AIl/Hv4DXHw5+HcPgaDxs3xO+BnjrQI/GninX9C8\
LX8nwj+M/gT4tanpOsa7ofgbVrvRUu9D8EapbwXEOl35S7ubcSW/ktJLF9Sx6jbjU7yUx3+17DTowBp\
epmQNFcaozF4RZ740ImTazKFchghYo4UvNRt3uNLYR34EN/JI4fS9TjYqdM1GICJJLMGd90qkqgZgoZ\
yNiOy9FGdehiqVejh+SrRjGUZcs3aUaacdG3F2kkrNO+zuzlx2Dw+Y4LF5fik6uFx1OdGpFNxcqdWLh\
NKUbNNxk1dNNXunex/Gdc/8EO/24f2Y/i/8Yv26vCmofsSyeItI+KX7QX7WeuWes+Kfih4z8T3kXirw\
J8TrKb4dWPim4+AOj3tl4X0vQviH48mtLHSL/wAN22v6zq1jfeL5NZj8P+FovD2d8O/+Cd3/AAXV+CH\
xJ+PXxk+GPwQ/ZF8QfEb9o3xDoGq/Ea/+J3xR8a61bXdt4W8U/GDXvDAt5W+PF09jLpPhr4m+H/CGlW\
enx6bo9p4W+FmhQrpx1Yapqmqf1r/tU6vZr+zB+0ezpfoq/AX4wFnk0nVY0RR8PfERLO72QCIBkkkgA\
DJOK8L/AOHo/wCwx/0Wm+/8NH8b/wD521fKZtx1isizd4fH8bf6oQcIYui54jC4d1sRWlXo4ipBY6FS\
MnCnTpQl7GMeVVWp35426sD4Y5Xn2WVKsuDanHCxFGnleJjXp4zGxWX4GvQx+Cwk5UJxqRoxxcp1oRl\
NczpQinyU+U/lK8AeHP8Agr3J/wAFdvDvgP4m/s4fsoaz8VNI/wCCf2ueMtY8G+APEuh+D7jVvhBqHx\
v0rwlf6jbfGbW9W1fUrfUrf43aFC9npN5LqWlQ6J9re20iy1fVrzWE/WHwn8BP2+vA9z4ptvA//BN74\
K+DpPFniTUPiH4xPhX9qf4XeHl8V+NfFLmPXPGXiM6R8K4f7c8WXp0m3+26jdebd3ItovOmk2Lj6r03\
9pL/AIJlxfthSftyv8dPG/8Awug/s56r+ykLFPh38XZPAv8Awq6X4z3nxkS6Oix/CE3I8Xf8JQ6o1z9\
v8lbXNu1mJgZR9NR/8FQ/2Ghqd5KfjTebHsNNjXHwm+NhfdFcaqz7ox8ONyLiVMMQFY7gpJVgFl3jH9\
TeYxj4xYWCVepOEp4zIK85punTVTnrYetNc8I6wUoRVvdpxRxcUfRn4KzaWVOn4R4qtThl2Eo1aVCjx\
BgqNOdJ1JewlSw9bCwqulObkq0416kpTu8RUsuX79sf+PrWf+wlF/6Z9Koi/wCQxff9g3Sv/SrWapWu\
mabNc6sJtPsZRFqCJH5lpA/lo+madOyJujOxTPNM5A4Lysx5YktTS9MfVr5X06wdRYabKFazt2USS3O\
rCWQAx/fYRx7j1OwZzgV9JJUv3t5y/hU/sr/p1b7f/DeZ3a9v6+4v33/H1o3/AGEpf/TPqtGs/wDIH1\
X/ALBt9/6Sy1QvNL0yO40tI9OsEWe/kimVLO3VZoxpmozCOUCPEiCaGJ8HI3RK3VQQappemQaZqM0On\
WEM0NheSxSxWdvHJFJHbyPHJHIkYKOrAEEEEEZHNEFS58H78r6W91a/vJb+/pr69/ISvr/XRHQ1m6V/\
x6y/9hLWf/TxfUf2No//AECtN/8AAG1/+NVQ07S9Mmt5Hl06wlYX+qRBpLO3dhHBqd5DDGC0ZIRIY40\
UdFVAowABWaVH2NT95K3ND7C7T/v/ANfk9br5/oX4v+Qxff8AYN0r/wBKtZovv+PrRv8AsJS/+mfVao\
R6Xph1O8hOnWBhjsNOljiNnbmNJJrjVElkSMx4V2WCEMQMsIVByFGC80vTI7jS0j06wRZ7+SKZUs7dV\
mjGmajMI5QI8SIJoYnwcjdErdVBGlqXtfjlf2X8q29j/j3trbvpfqJ3tr3X5ov6z/yB9V/7Bt9/6Sy1\
pVz2qaXpkGmajNDp1hDNDYXksUsVnbxyRSR28jxyRyJGCjqwBBBBBGRzV/8AsbR/+gVpv/gDa/8Axqs\
2qPsaf7yVuaf2F2h/f/r83r2DSv8Aj1l/7CWs/wDp4vqIv+Qxff8AYN0r/wBKtZqhp2l6ZNbyPLp1hK\
wv9UiDSWdu7CODU7yGGMFoyQiQxxoo6KqBRgACiPS9MOp3kJ06wMMdhp0scRs7cxpJNcaoksiRmPCuy\
wQhiBlhCoOQoxpNUufGe/K+t/dWn7yO3v66+nfyEr2Q61tJ3udW26nfQ7NQRWMcemnzSdM06QO/nae+\
GCOsY27V2QqSC5d3alncNq18Bql+h+waa+5Y9MLFXudWCxHfpxGxdrbeNx8w7mb5drrWTUhc6t5NpYu\
TqCGTzNQni2ONM04KqbdMfzFMAhYk7SHdkCkIJHakmpjVr7ZZ2DN9g00ENqNwi+WLnVvKcMNLbLkmTc\
uMLtGGbcduj9p+9t7P+FDf2X/Tvv07X07dA003/ELyzuFuNLB1S/kMl/IiO8emBoGGmajIZYhHpyguV\
RkO8Ou2ZiFDhHU1SzuI9M1GR9Uv51SwvHaGWPTBHMq28hMUhh05HCMAQdjq2CdrKcEF5JqZuNLMlnYK\
wv5DCE1G4dZJP7M1EFJWOlqYU8kytuAclkVNoDF0NUk1M6ZqIms7COE2F4JZItRuJpEjNvIJHjifS0E\
rhckKXQMRgsoOQR9pz4X+H0v/AAv+fktuu38vXzuGmu/49kX/ALDdf9BnUv8Av1o//wAqqoadZ3D28h\
XVL+EC/wBUQpHHphUtHqd5G8pMunMd7spdsEKGkIRUTai3/N1j/nx03/wa3X/ymqhp0mpi3kEVnYOv2\
/VCTJqNxEwkOp3hmQKuluCizGRVbILqocqhYoua9r7Kf8K/NH/nzbafyv2vrvbqHVf8HyCOzuDqd5GN\
Uvwy2GnOZhHpnmSK9xqgWJwdOKBEMbldqKxM7b2YBAheWdwtxpYOqX8hkv5ER3j0wNAw0zUZDLEI9OU\
FyqMh3h12zMQocI6kcmp/2neEWdgZjYacJIzqNwI1jFxqhidJRpZLuzGYMpRQojUhnLkIXkmpm40syW\
dgrC/kMITUbh1kk/szUQUlY6WphTyTK24ByWRU2gMXTT957T/l3b2f/Tq9/Zffa/yt/dB2tpfdd+67h\
qlncR6ZqMj6pfzqlheO0MsemCOZVt5CYpDDpyOEYAg7HVsE7WU4Iv8A2G6/6DOpf9+tH/8AlVVDVJNT\
OmaiJrOwjhNheCWSLUbiaRIzbyCR44n0tBK4XJCl0DEYLKDkX/N1j/nx03/wa3X/AMpqzftfZQ/hX5p\
f8+bbQ+V+9tdr9B6ef4lDTrO4e3kK6pfwgX+qIUjj0wqWj1O8jeUmXTmO92Uu2CFDSEIqJtRSOzuDqd\
5GNUvwy2GnOZhHpnmSK9xqgWJwdOKBEMbldqKxM7b2YBAhp0mpi3kEVnYOv2/VCTJqNxEwkOp3hmQKu\
luCizGRVbILqocqhYopHJqf9p3hFnYGY2GnCSM6jcCNYxcaoYnSUaWS7sxmDKUUKI1IZy5CaS9pz4r+\
H1t/C/5+R367fzdfOwla0d/xHWuoQRXOrbo74+ZqCOvl6ZqU2AumadCQ4htG8pt8TEK2GKFZACjozNT\
UbdNWvmMd+QbDTY/l0vU3bdHc6sWJVLMkId67WxtbB2k7Wxfsf+PrWf8AsJRf+mfSqIv+Qxff9g3Sv/\
SrWazk6X728Jfwqf2l/wBOrfY/4fyHr3/r7yheajbvcaWwjvwIb+SRw+l6nGxU6ZqMQESSWYM77pVJV\
AzBQzkbEdlNU1G3m0zUYkjvw0theRqZdL1OCMM9vIoMk01mqQpkjLOyqoyWIAJq/ff8fWjf9hKX/wBM\
+q0az/yB9V/7Bt9/6Sy0QdLnwfuSvpb3lp+8lv7muvp28xK+v9dEH9q2v/PLUv8AwTax/wDINUNO1G3\
it5FaO/JN/qkgMel6nMu2bU7yVAXis2AcK4DKTuRgUcK6so6Gs3Sv+PWX/sJaz/6eL6s06Psan7uVua\
H212n/AHP6/N63Xz/QoR6jbjU7yUx3+17DTowBpepmQNFcaozF4RZ740ImTazKFchghYo4XzT46fEO8\
+Hvwl+InxE0K0FzrPw/8BeP/G2lWusaNrbaZdal4Z8B+JtW0+3vreAW815Zve21uJ47eaOYwmRlkiCt\
KnrUX/IYvv8AsG6V/wClWs1Q8R6Vpeu2sGia3pthrOi6y+o6Vq+karZ2+o6Xqul6j4f1m01DTdS0+7j\
eK+sJ7SaWKaGVGjljlZHVlYg5YyDrUMVRw0pYfE1cNUjTqcy9ycsO1CVuS/utp+qvbob4apSpYnDVcR\
T9vQp1ISnD+eCnFyjv9pJr5nxb4t+Mvxv8AfHj4AfB3xhrvwy8ZeHPjvYfGyPUL/w78G/iH8PNZ8Pt8\
Nvh8PElibS+1z4u6/a3CXWoX9okzTW8awwWsnO6VZYPuH+1bX/nlqX/AIJtY/8AkGvJLH4A/AjwTLce\
J/BnwU+EnhHxLpmm6v8A2b4h8MfDjwdoGuaf9t0q90+8+w6tpWjRXFp5thd3UEvlyL5kNzJE2UdlPtt\
eNkeCxmBoZh/aNWVWnisXKph6X1qrifq1FYTB0pUfrFelGrU5sRSr4j3ork9vyJtRR6Ob4vBYt5f9So\
+zlh6Hs69T2NLD+3q/WK9RVfY0ZSpw5aNSjRsn73sed6yZz2najbxW8itHfkm/1SQGPS9TmXbNqd5Kg\
LxWbAOFcBlJ3IwKOFdWUEeo241O8lMd/tew06MAaXqZkDRXGqMxeEWe+NCJk2syhXIYIWKOFv6V/wAe\
sv8A2EtZ/wDTxfURf8hi+/7Bulf+lWs19FN0ufGe5K+t/eWv7yO3uaa+vbzPGV7I/9k='
	$begin 'DesignInfo'
		DesignName='main'
		Notes=''
		Factory='HFSS 3D Layout Design'
		IsSolved=false
		'Nominal Setups'[1: 'SIwaveDCIR1']
		'Nominal Setup Types'[1: 'SIwaveDCIR']
		'Optimetrics Setups'[0:]
		'Optimetrics Experiment Types'[0:]
		Image64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCADIAMgDASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+7USZ1K/Hm5/0G1OPPz96fxGM7f7Ubru67Pm3f\
el3Yl0jJ++uT5v3pbI58/721k53f2p8+Mdd8m3H3oeowjeTC9vWFtdOxtYlMC3VkZFVZvERSZg3iAoU\
lLbUxliT+83Bv3ugb6fz7v8A0O8x52n4f7Xp+2Ub03Orf8JHlhH1YlnK7flMfUfSVqcnOOsfhh9qK/5\
9rq/632OcsI+PL/eYx5P/AC2xjH9n/wDUQXGNn+zjy/4Nn7ilpMmdN0s+bn/QdPOfPz/yw0s53f2oc/\
c67z9z7w25gI76f91mwvl/1Gc3Wmjb/wAgvOceIBjb82cYx9mbG3anlVNNvJkstOVba6mVbWwVZ47qy\
8uVRFpAEyGXxAH2EbmG7DAW7Z2lV8qlTl7OSvHVx+1HtLz8/wA+zA2EfHl/vMY8n/ltjGP7P/6iC4xs\
/wBnHl/wbP3FK7kx/Zi+bjN9INvn4z/xTuoLjZ/ai7umMeW/TbtGPKUjvp/3WbC+X/UZzdaaNv8AyC8\
5x4gGNvzZxjH2ZsbdqeVUuLyYpYk211EyXTskD3Vl5lwx8O3imGJY/EG0uNzA712/uGUfwRUQpyu9Y7\
S+1H+V+f8Aw3yYGw758z95nPnf8ts5z/aH/UQbOd/+1nzP49/78d8+Z+8znzv+W2c5/tD/AKiDZzv/A\
NrPmfx7/wB/Skvp/wB7iwvm/wBfjF1pp3f8hTGM+IDnd8uM5z9pXO7c/mkl9P8AvcWF83+vxi6007v+\
QpjGfEBzu+XGc5+0rndufzZ9nLvH/wACj/mAWUm6C4Pm7s32sjPn78/8TLWxjP8AakmfvYxk/fxt+bZ\
NpCTmT971liP+v64vpnz/AMhQZxndn5sZ3blz5z4VveTLFcBLa6uQbrVW3xXVkVLPe64zQ/vvEBJdWI\
jbqu6UbdyMfN0Fvp8yf6HeD99Bg/a9P+Yf2lcZcf8AFR8gLiQk5IWQMCrEyMVqcnKbvHWX80f5l5gRX\
sm2C3Pm7cX2jDPn7Mf8TLRBjP8AakePu4xkfcxt+XZDdR8eX+8xjyf+W2MY/s//AKiC4xs/2ceX/Bs/\
cY9xeTNFbh7a6tgLrSm3y3VkFDJe6Gyw/ufEAIdmBjXou6I7tqKPKtx30/7rNhfL/qM5utNG3/kF5zj\
xAMbfmzjGPszY27U8q3Tl7KCvH4pfaj2h5/8ADdQLqPjy/wB5jHk/8tsYx/Z//UQXGNn+zjy/4Nn7il\
ZyZkvB5udur2Jx5+dm3RdKGdv9qHy8euyHH96PpRHfT/us2F8v+ozm600bf+QXnOPEAxt+bOMY+zNjb\
tTyqlteTKZiLa6kZ9VsGeJbqy32Z/sfTVImD+INqlQqkmMKAJAA6NuQEKcuWrrHWK+1H+aPnp8wNh3z\
5n7zOfO/5bZzn+0P+og2c7/9rPmfx7/39LVpMabqh83H+g6gc+fj/lhqhzu/tQY+/wBd4+/947szkl9\
P+9xYXzf6/GLrTTu/5CmMZ8QHO75cZzn7Sud25/NqaleTPZairW11CrWt+rTyXVl5cSmLVwZnMXiAvs\
A2sduWIuFxuLN5pSpyVWm7x0lH7Ue68wNh3z5n7zOfO/5bZzn+0P8AqINnO/8A2s+Z/Hv/AH8ok5k/e\
9ZYj/r+uL6Z8/8AIUGcZ3Z+bGd25c+c+bJfT/vcWF83+vxi6007v+QpjGfEBzu+XGc5+0rndufzZVvp\
8yf6HeD99Bg/a9P+Yf2lcZcf8VHyAuJCTkhZAwKsTI2UqcrLWO6+1HuvMCIyY1KwHm4/0G6OPPx92fw\
4M7f7UXpt67Pl2/ei24iuo+PL/eYx5P8Ay2xjH9n/APUQXGNn+zjy/wCDZ+4xxeTG9smNtdIwtZVEDX\
VkJGVpvDpeZQviAIEiK7XzhgR+72hf3VuO+n/dZsL5f9RnN1po2/8AILznHiAY2/NnGMfZmxt2p5Wkq\
cmqesdF/NH+Z+fn/VmBdR8eX+8xjyf+W2MY/s//AKiC4xs/2ceX/Bs/cUtJkzpulnzc/wCg6ec+fn/l\
hpZzu/tQ5+513n7n3htzAR30/wC6zYXy/wCozm600bf+QXnOPEAxt+bOMY+zNjbtTyqmm3kyWWnKttd\
TKtrYKs8d1ZeXKoi0gCZDL4gD7CNzDdhgLds7Sq+UKnL2cleOrj9qPaXn5/n2YGw758z95nPnf8ts5z\
/aH/UQbOd/+1nzP49/7+lfSfv7Aeb96+uhjz/vZ03xAcY/tT587s4xLndna27fKSX0/wC9xYXzf6/GL\
rTTu/5CmMZ8QHO75cZzn7Sud25/NqXl5MZrYm2ukKXV0yI11ZbrpvsXiBfJh2+ICGcq3mfvMqVf+J2/\
ekKcrvWO0vtR/lfn/wAN8mBsO+fM/eZz53/LbOc/2h/1EGznf/tZ8z+Pf+/KpSX0/wC9xYXzf6/GLrT\
Tu/5CmMZ8QHO75cZzn7Sud25/NKqnSk+bWPT7cF+cgJTJOdQvwzTbfsducFHC7mn8TeZydMXnDPn5uM\
nKxYJj0jJP592d024zaeXOx9xZXTy9w/szgg425WPPZZehyBHjUr8+Vj/QbUZ8jH3Z/EZxu/stem3pv\
+Xb92LbmLSMf765HlfdlshjyPu7mTjb/ZfyZz02R7s/dm6HmrRipxtFL3YdP+vQXfcI3mHlYaXjyMYV\
u39l7cYsDn7kWPvdF+9kefS0qSc6fphLTbvsenEko+7d5Gj44/swc5SL+EdF+U5AmsImfL/d5z5P/LH\
Oc/2f/wBQ9s53/wC1nzP49/7+lpMeNN0seVj/AEHTxjyMf8sNLGNv9ljH3+mwff8Aundie1GPs5e6vi\
j08pBd9zSjeYeVhpePIxhW7f2XtxiwOfuRY+90X72R59K6knC6coabYbyQMAjlSv8AwjV+vzEaYwA8s\
L/y0TjB3EfvWsImfL/d5z5P/LHOc/2f/wBQ9s53/wC1nzP49/7+ldx5/sxvKzi+kO7yM4/4p3UGzv8A\
7Lbb1znzE67txz5rFOMeZ+6vhl0/usLvuaUjzHzctLz5+cq3f+1N2c2Ax9+XP3erfdwfIJHmPm5aXnz\
85Vu/9qbs5sBj78ufu9W+7g+RE6Y8z93jHnf8scYx/aH/AFD1xjZ/s48v+DZ+4HTHmfu8Y87/AJY4xj\
+0P+oeuMbP9nHl/wAGz9xHLH+VfcF33K9pJOYLje0xP2zWAdyODt/tDXhznTI+NrSdhwW+bgtFpLJPm\
T5puZoCfkf7w1K4Zc/8Sw8+aWI6fMSNrH9ymRZR7YLgeVtxfayceRsx/wATLWznH9lx4+7nOB9zO75d\
8OkI+ZP3XSWIf6jpm+mTH/ILOM424+XONu1seSjrRjzz91fH2/vId33KV3JOILfY0wP2zRwNqOTt/tD\
QRxjTJONqx9jwF+bkNLdjeYeVhpePIxhW7f2XtxiwOfuRY+90X72R5+bex7oLceVuzfaMceRvz/xMtE\
Ocf2XJn72c4P387vm3zXUTPl/u858n/ljnOf7P/wCoe2c7/wDaz5n8e/8Af04x9lB8qvzS6LtAV33JY\
3mHlYaXjyMYVu39l7cYsDn7kWPvdF+9kefStJJ91yC021dY08xgo+0MNE0rZsP9mDccdMNLnssnWrCJ\
ny/3ec+T/wAsc5z/AGf/ANQ9s53/AO1nzP49/wC/pWceJLw+Vjdq9iM+Rjfu0XSjjd/ZY8zPpvmz/dk\
60QjHlq+6tIrov5ohd9zSkeY+blpefPzlW7/2puzmwGPvy5+71b7uD5FLVZJxp+pkNNu+x6iQQj7t3k\
axnj+zDzl5f4T1b5RgiGw6Y8z93jHnf8scYx/aH/UPXGNn+zjy/wCDZ+4patHnTdUHlZ/0HUBjyM/8s\
NUGNv8AZZz9zpsP3PujbiApRj7WkuVW5o9F3QXfc/na+G3wQ8c/tbftH/FPw34i/bJ/b0+E1na/Fn/g\
oPqco+CH7V3xM8KWs1r8Mf2xb74a+AfDlt4a8SPrOjeGvDGleD9Sntbaz0fStKQJEglJRDj079qj/gm\
54k+DX7MH7Snxf8If8FMf+CtDeLPhT8Cvi18SPDC6x+2VqV5pLeIvA3g3xT4n0RdWs4/hvA15p51TS7\
fzo/Pgd1MgSRJWYJ4t8Jf2ovDv7Kv7RfjrxZ4t+FPx7+Iug+I/i/8A8FRPDf2z4JfCjVviWnh7V/8Ah\
vY6hp9p4oGmCIaE97aWmqPYiRVNz/Yd55aobdmT1j9rv/gql8Lvij+yf+1D8M/B/wCzB+3be+LfiN+z\
38Z/A3hazf8AZX8UxpdeIfFvw+8U6Hotq0kTF40kv9StIyUAIDcKwCxLHEX1nDZ3mGHhgsdGNWllcsN\
7DC42VBqeT5bKcoSoUpUPexTryqNy/iuo6mrbPzjhXGcP4jhelVx3EWXQzuGM4hhUhi83wlHEqVLiPO\
aWFhKhicXCrywwkMLToR9nyexjSjBOKSOEHgS/DKw+Nv7XgZBtVh+2/wDtjblXMJwp/wCF6fKM28HT/\
ngn91cOHgXURjHxu/a+GMYx+3B+2MMbfL24x8dOMeTFj08pf7ox3lFf2f8A6t8O/wDQhwX/AIS0P/lZ\
/mJ/xEDjz/ots3/8OWM/+XHBjwLqIxj43ftfDGMY/bg/bGGNvl7cY+OnGPJix6eUv90YztT8MxeH9Kv\
9Z1j4/wD7VuiaHoen3Wp6pqup/t1/tfabpWkaVpdt9rvNQv766+PCQ6fp9vaWfmSyyOkcMdrvdlVMj0\
2vGP2kNA8UeK/2ePj14W8D6H/wk/jXxL8F/ijoHhDw1/aenaL/AMJD4o1nwPruneH9D/tnV5o7TSfte\
rXNpb/abqSO3g+0ebO6xIzDmxuQZFh8Hi69DhvB169GlUnCmsJRbnOMG4wSVO7cmkklrrpqdWA4445x\
eOwWFq8eZrh6eJq06cqk80xUIwjOcYucp1MRGEIxT5pSnKMIpXk0k2eSn4/fsxHUDpB/4KFeOTqpsm1\
E6Yf+CpHx/OoHT2nktmvzZH9pnzDZG5mljMu3YXlZN25iD6t4Ofwn8SNMn1zwB+1F+0f490a01CfTLn\
WPB3/BQP8Aat8U6ZbarHaxXNzp8+oaL+0BPFDqC2WqwyPEziQRakrsuyYFv4KvjLp3xj1P9pbx78bPi\
t4Ht/gl4Y+Lvxr8X6jf+CvH/wAW9D8LfHP4I+D/AIqfFzWvifrGr/Ef9nnwBrn/AAtK30DTPDGq69qQ\
ubnwmsd9p9xY63Z293ZXOkw3X6ufsW6tov7F3x0vP2hPjR8bviJ4B/Yv8Faj40+Ed94u0LU/jrL4d+J\
X7XMWlNpw+D3xZ+CXjHwmPHV1Y+GvA9z8RdRtW1bwlpNhpPiXw47Q6o0sy22ofiuScY0Mdn+FwGP4Ay\
/CZNVv7XFzw0MM6UHTnUjWqUsRBTp03CF5KpGKj7y9o3Fc39acX+EfFWSZZKeSeMOfZ5nX1ec6VHDYn\
EY7C4vHUoXeW4LGYHGVKeLxdWbVOhDCqv7VKdel7XDQ9s/6qD4F1E5z8bv2vjndnP7cH7Yxzu8zdnPx\
05z50ufXzW/vHJX84Pwl+OPw4+IHjv4T6l4A/bH/AGtdW0z4LfHb4Q/AbwPYfE39sj43aZZ/tK+IPi5\
8RviV8YfgTqvxm8L6H+xBq0GtWHjDRLfxDotwt/qOntpvhzwVY6Frbac0Fnd35X6VlOK4MzWjKvh+Ha\
MqWlpUssqVoyvdN81PB2spKUYvaaTlFuOp+EcaYfxO4OxWEwuJ47zpVMVGcrYzGYvLZqKcJ0nGGLxil\
U9rQqUa75f4casIy11f+iobOY3t6oubpGFrExnW1shIytN4iCQsW8PhAkRXcmMMCP3m0L+60DYz+fd/\
6ZeY87T8J9k0/bEN6bkVf+Ecyok6MCqFt3yiToYhHjUr8+Vj/QbUZ8jH3Z/EZxu/stem3pv+Xb92Lbm\
LSMf765HlfdlshjyPu7mTjb/ZfyZz02R7s/dm6H+Xq1SSnHSPww+zF/8APt9V/W2x/p2ZsdjP+6zf3z\
f6jObXTTu/5Bec48PnO75s4zn7S2N25PNqabZzPZacy3N1CrWtgywR2tl5cSmLSCIUEvh8vsA3KN2WI\
uGzuLL5uwiZ8v8Ad5z5P/LHOc/2f/1D2znf/tZ8z+Pf+/paTHjTdLHlY/0HTxjyMf8ALDSxjb/ZYx9/\
psH3/undielUl7OTtHRx+zHtLy8vz7sAjsZ/3Wb++b/UZza6ad3/ACC85x4fOd3zZxnP2lsbtyebUuL\
OYJYg3N1Kz3Tqk72tl5luw8O3jGaJo/D+0OdrE722/v2YfwS1sImfL/d5z5P/ACxznP8AZ/8A1D2znf\
8A7WfM/j3/AL+ldx5/sxvKzi+kO7yM4/4p3UGzv/sttvXOfMTru3HPmsQqSu9I7S+zH+V+X/D/ADYBJ\
Yz/AL3F/fL/AK/GLXTRt/5CmMZ8PjG35cZxj7Mudu1/KJLGf97i/vl/1+MWumjb/wAhTGM+Hxjb8uM4\
x9mXO3a/lXXTHmfu8Y87/ljjGP7Q/wCoeuMbP9nHl/wbP3A6Y8z93jHnf8scYx/aH/UPXGNn+zjy/wC\
DZ+4n2ku0f/AY/wCQGPb2czRXBS5urYC61VdkVrZBQyXuuK0377w+CHZgJG6LuiG3ainytBbGfMn+mX\
h/fQYH2TT/AJR/aVxlB/xTnAK4jIOCVjCgMwMaxWUe2C4HlbcX2snHkbMf8TLWznH9lx4+7nOB9zO75\
d8OkI+ZP3XSWIf6jpm+mTH/ACCzjONuPlzjbtbHkoVqklKatHSX8sf5l5AYVxZzLFbl7m6uQbrSl2S2\
tkVLPe6GqzfufD5JdWJkXqu6U7tyMPNtx2M/7rN/fN/qM5tdNO7/AJBec48PnO75s4zn7S2N25PNL2P\
dBbjyt2b7RjjyN+f+Jlohzj+y5M/eznB+/nd82+a6iZ8v93nPk/8ALHOc/wBn/wDUPbOd/wDtZ8z+Pf\
8Av7dSXsoO0fil9mPaHl/w/UClHYz/ALrN/fN/qM5tdNO7/kF5zjw+c7vmzjOftLY3bk82pbWczGYC5\
uo2TVbBXlW1st94f7H01iZi/h/axYMoIjLAiMEI7bnOwiZ8v93nPk/8sc5z/Z//AFD2znf/ALWfM/j3\
/v6VnHiS8PlY3avYjPkY37tF0o43f2WPMz6b5s/3ZOtEKkuWrpHSK+zH+aPlr8wCSxn/AHuL++X/AF+\
MWumjb/yFMYz4fGNvy4zjH2Zc7dr+VU1KzmSy1FmubqZVtb9mgktbLy5VEWrkwuIvD4fYRtU7cMBbrj\
aVbyth0x5n7vGPO/5Y4xj+0P8AqHrjGz/Zx5f8Gz9xS1aPOm6oPKz/AKDqAx5Gf+WGqDG3+yzn7nTYf\
ufdG3EBSqSdWmrR1lH7Me68gP43P+Ch0z2P7Df7dlwuo6VpUlp+1b+1LOureIY9ROh6a8H/AAUa8eSL\
qGuQ6Fpz3Z0mEqJLlbO0e58mJxb27y7Iz+emtfBv9kbTtf8A2mPCEHxP/YTj+HXwO034k678P/8AgoP\
quqftBXf7Gnxw8W+C/gf+zh8StE/ZZ8NeFfhx+294m8SN8ddQ1r41ePJJLnQtU8U30ukfBjULfwr4G8\
YeIF1/TfCv6Oft8jH7GX7bQxtx+19+0yMbduMf8FI/G/G3yk2/TYv+6OlfoJ450nxLr/gnxhoXgzxa3\
gDxjrXhbxBpPhPx2mhab4ofwV4l1LSbuz0LxanhnWSLPxE2m6pNa3gsbsi2uzZfZ5yIpHr9pfCWG4pz\
GhKvGlUnl/DOSckamCweLk5VquaP939aSjTlai4v34Rk5xblD2d3/AmD8Rsm4Gx/EOGzXhiOdQzPjTP\
ZzryzHGYCNGlSeChJVVg8PiatWClWVbSlVsqc4/VsQ6kYx/nn/Zb+EHwQ+O3i/wCHk/jP9nf4HeALvx\
v8R/iP8OfiR+xS/wAS/wBraw/bb/ZK0Pwp8HtH+JXgL48/GmHxrrWlWnin4ReKdatdR0pLqy8L6Lo2m\
S/Fn4f2sHizXNfvNb0DTvWvB37KH7Ovi342eC/2RtQ/Z/8Ah9aeOfgF8dP2mfi/8X/ijpX7Y9vrGt/E\
f9lX4h6Z4g1r9nL4ZzfAPw54yXxxpHizSdX+OfwrtdSvfE2labpWkWXwFtbnRvFHiCPxxFZL+ybeEvi\
Z/wAKSbwInxcYfGT/AIVWfCSfHh/Afh13HxM/4RL+x1+Lj/DFZl0l2/4SnGsnQRIunE/8S8OLb5q8A1\
v4sfs7+Lf+Cd37EX7DHwn/AGMv2gPAHxo+Dvx3/Y8MXw58dfs46hJ4e/Zw8Q/s4/HLwl48/aD+O+t/t\
ZN8L/Dnw08a3GueCPA3xkRPGXgjVJNe+IF58dFKeH7eTxRr1laRm3BmRZPV4Zo1uDKGc1cVjpV5VYYD\
A4dUYyUaawteGGw9aFRKNWalZxhKPtIU5SpzlGP2vBXGGG40oeJ+LybiDCcA5fhMijln1WpjcwzFVJJ\
Yuc88wtfM8Tl9eh+7pwpUlNV8RGfssTjZU8VCjPFYX/Dsv9iH/oif/mSPi5/83tfmZ+3F+zj+yR+yn4\
quvFfjN/hN8Mfg94s/Zy+KXhH4N+EpvGnx21740eMf2vpL6x1fw34ouNKW+1Kxt/hDoHhLTLWCTUZ7i\
y0qy1Tx4yeJxPBdaHJafrx+3J8T/C/we/ZB/aL8e+L/AB74r+F2k2Xwq8U6BafEHwJpWoa3448J+KPH\
Nk3gTwRq/gzTdM1jTZJ/FaeNPEugDTmbVNJt4rySGa71fSrSObULb+bvxz+0t8XPhb+1Z8dPgB+1z8Y\
/Fn/BLPxr8JfgH4vvdMtbjxn+0j+3v4u8R658f/2av2avDPxG/ZGi8ewfG/xNFbfA74nx2R+JWmzazJ\
rF78MtestOXSfFMGt6fBeDo8Q8v4IyDLsThcNwTlssxrYapWoungMNzKUHyqLhQoSxDclzOnyQfNOHK\
rtNHgfRx4B448TsRic/xfFmZVOHcvrzwWJpe3rTrVPaYZTVTCVMVUlhXUoVauG+se7OeHoVvaN0p1cM\
6nf/APBR39iL43+Jf20PjT8XZv2ZfEnx1+GHxk8ffs+av4YHhHw7p3jFJ/Dvwn+Clj4O8daV4xvPCNp\
a+NPhxpl14tvNIAbRfE2iNqtnod4smla3cRaXqPhz1v8AYN/4KU/spfAHx/8AHz4T+K9V8FfB/wCC3j\
n4jaT8QPgZZ+Dvg/8AEXw5JF438VGfwf8AF7wzqvgTRvGvjdfCOhv498JvJ4fttLup9FsLa3v1ludIs\
7rw9o0X7VftN/Fv9p74W/8ACE/8M4fsi/8ADVP9u/8ACS/8Jl/xfz4ffA7/AIQT+yxoJ8O/8j3ptx/w\
lH9qHUNc/wCPXZ9h/wCEe/f7vtcO3+dj9q3/AIJtfCD/AIJ5eF/2YP2kfF3ju9/aE+IeifG+XwLqnhX\
xn8LreL4V/Fbxv481vxl8RPh9fa94d0L4raXdeAfCnh1dO8R3d7bi88UxeI9RjsrK80620S4vLRI4hy\
PPOGeIMZxVkOOli8Hh54nF42OMov2eHjUhOcY4dxVH63CUq9bmjSnOtSjTpUufnsp7cF8SZP4l8I5Rw\
X4l4x0KWLwOHy3IcJk2Lo18XiKmVYZwjiMXgVPGRyrF2yvAYGGLzCjhHjKOPrVaUauBhVr4L7U/al/a\
a+HX7Mn7JniX9pX9jv8Aah+IQ8T/ALWPxI8T/Fn4I+Ede+GOk+JPBHxH8b618QfCuk/E+CPTtY/Z/Ov\
eGIofDrXcOl2+q6ppkUl5Z2SiW5aWb7QVqfDb/gnd+1rdftGzaV8S/iN8G5P2Tv2WbmRP2Tfh54g/Zd\
+FPiD4S+NNA+L/AII1eLx34dbwV4c+KVt4n0KPwdrn9g20GoeKdW1XVfEF7pya1JfTyz6hJclYV+HvE\
HF1efAU6uR4OlCnTjQw+MxNGn7SMIvFVFSeZxUIzxksR7DkvCWFjQmm5TnKXNl/HHg3wBho5VmHDuS+\
K2OzF/X5Zhiqf1mph6GKUXgcvnVWTYa+Iw2Xxw0sfG9T2OYVcVh26U6M6FP+8Q3+mre3sx1Q+U1rFEr\
yapp5gaSCbxE0qri5+aYKUMuOqyNjO9M6B1LSvPu1/tcZSbTwf+Jtp3mEyOgXzm+04d+f3RBIU43YqI\
SZ1K/Hm5/0G1OPPz96fxGM7f7Ubru67Pm3fel3Yl0jJ++uT5v3pbI58/721k53f2p8+Mdd8m3H3oeo/\
GKzp88bwk3yw+0v+nf919P8/I/ugzY9U0o+VjVoufIxt1TTx97+y8bM3PH+tXbnpiHONj7amm3+mxWW\
nQy6oY5Y7WwikSXVNPE6SLFpCssmbn5Zg0gHPRliz9x9uwj48v8AeYx5P/LbGMf2f/1EFxjZ/s48v+D\
Z+4paTJnTdLPm5/0HTznz8/8ALDSznd/ahz9zrvP3PvDbmCk6fs5e5K14/aXaX931/DtqBHqmlHysat\
Fz5GNuqaePvf2XjZm54/1q7c9MQ5xsfbUuL/TZEsZU1QskN08spi1TT/s6Rnw7eANcL9pz5O6WNRx9x\
0T7/FbCPjy/3mMeT/y2xjH9n/8AUQXGNn+zjy/4Nn7ildyY/sxfNxm+kG3z8Z/4p3UFxs/tRd3TGPLf\
pt2jHlKQdO7tCW0vtL+V/wB31/4PUCTVNKHm51aLjz879U08/d/tTO/Fzz/qm3Y65mxnem4k1TSh5ud\
Wi48/O/VNPP3f7Uzvxc8/6pt2OuZsZ3puuu+fM/eZz53/AC2znP8AaH/UQbOd/wDtZ8z+Pf8Avx3z5n\
7zOfO/5bZzn+0P+og2c7/9rPmfx7/383pfyS/8CX/yIGPb3+mwxXCy6oUb7VqsoFzqmnlzHLe65NGxx\
cnMLRAMuOsbyY++m7QXUtKzJ/xNxxNADjVtOzltSuIxv/0nl9ykqRwJdznCkExWUm6C4Pm7s32sjPn7\
8/8AEy1sYz/akmfvYxk/fxt+bZNpCTmT971liP8Ar+uL6Z8/8hQZxndn5sZ3blz5zlZ0+ad4Sb5v5l/\
Mv7oGFcX+mzRW6xaoXb7VpUpFtqmnhxHFe6HNIwzcjEKxEs2ekaR5+4+23HqmlHysatFz5GNuqaePvf\
2XjZm54/1q7c9MQ5xsfaXsm2C3Pm7cX2jDPn7Mf8TLRBjP9qR4+7jGR9zG35dkN1Hx5f7zGPJ/5bYxj\
+z/APqILjGz/Zx5f8Gz9xbdP2UPdlbml9pdoX+z/XmBSj1TSj5WNWi58jG3VNPH3v7Lxszc8f61duem\
Ic42PtqW1/pqGZ31Qqtxqtg0Jk1TTxC6to+mpvsh9pypEkcioxwFKMrEEEVsI+PL/eYx5P8Ay2xjH9n\
/APUQXGNn+zjy/wCDZ+4pWcmZLwebnbq9icefnZt0XShnb/ah8vHrshx/ej6UQdPlq+7L4Vf3l/NH+7\
/mASappQ83OrRcefnfqmnn7v8Aamd+Lnn/AFTbsdczYzvTdU1K/wBNlstRhi1QySyWt/FGkWqaeZ3ka\
LV1VY8XPzTFoyOOrNLj76bth3z5n7zOfO/5bZzn+0P+og2c7/8Aaz5n8e/9/S1aTGm6ofNx/oOoHPn4\
/wCWGqHO7+1Bj7/XePv/AHjuzOUnT9rTtGSfNH7S7r+6B/Gv/wAFD9Jsdf8A2J/21re5udVFsv7Yf7S\
9xHNpXiDWNFupT/w8d8ewjzdR8O6lbyXMRjnclDI0TOEk2l442X9M9K0y20bT7fTLN76S2tVdYn1LVd\
U1q9KySvKRNqes3lxc3WGkYL5sz7ECxptjRVH5xft8nP7GX7bRzuz+19+0yc7t2c/8FI/G/O7zX3fXe\
3+8etfoJ4L8YaT4+8Nad4s0O08U2Gl6o1+lta+NfA3jb4beJYjpupXmlXB1HwX8RfD+laxpCtdWMzwN\
d2EC3Vs8N5amazuLeeX+meEKlP8Atr2UppVXw3w9KEW1zcqq5uqkoreybpKbStd01L7J/lT4k0cVKWe\
4iNKpLB0OLeJITmoydKFWq8BKnCUvgjOpGlVlCLalONOo4pqErdTRXK+O/G/hj4Z+B/GXxH8b6n/Yng\
z4f+FPEPjfxdrP2LUNS/sjwx4U0i817X9T/s7SLS4u7/7PpVhdy+TawTXEvlbIYpJGVG8T1rwt+398L\
/2bPgL+2F8Zj+znoPhv4ofFD4BaN8Uf2TP+Fc/GDwj8Z/gf8Pf2qPin4Y+Evw2sZPjX4k8f3Ft4z+Nn\
hXXfit8K5PGWhX3w08K2Esun+KdP0/VLaXT7C4vvq834kynJMRl+FzDEOnXzOfJSjGLm370Y80lG7jG\
8krvd3STszyOC/C7i/j3Ls+zXh7B06mC4egpVp1q0aCqTdOpVVGg52VWryUm5K8YU+el7WdP21LnX9s\
rTrTUf2Tf2kDda9pXhCbSPgp8R/FWieOtZh1yW0+HHizwZ4W1Pxb4M+KEMvhbRtR1bTtW8MeLdE0XX7\
C+0axu9Z0++8OW99pEEmpW9qK/GDwFY6D+yHY/8FFvDEU3gH/glb4w+G3g9NF8L/s4aD8ftE/aB+Inw\
6f8Aan/Zo8Ga144+AHxB+Nv7Q/w+1rwN8WtL+KFz+yp8I/HuiQeB59Q8Z+HRHqOhf29oRjvNJf8AbT9\
rK5+x/ssftL3f9seFPD32X9n/AOMtz/wkHjzw5/wmPgfQ/I+HXiOX+2PGfhH/AIRbXf8AhKvClrt8/U\
dN/sTWPt1nBNa/2VqHm/ZJv5OPDvw9+I/wZ8AeJfHXw78I/F79h9PAl9+0L8DNc8F/tj/Clvjhp/wu+\
HXxN+CP7Llz4y+HWu23hn/gnLq154c/aY+Nd7+0Feab4e+ImvaR4Rkf4c+F9P8AATarqWmnTIZvzvxO\
lShUcq2Ap5nReWY1VKNWLnTnFuEVzxj7R2hKSqK9Covcem8qf9TfRXwmIzLgriTLsPxDiOF8RW4gyuW\
HxtCdOE6VanQrVZQg60VSlLE0aU8JJe05+SvpKmm8Jmf9Tvgj4u/E/wCJn7QGmXXw4tfhV8QP2HNb/Z\
/vfEWjfHzwR4t8PeK9Q1f9obTfitd+FtR8B6Zf6D4+uI7/AMK2/gywvp5potDeKLVLKW1fWVnjfT1/H\
r/gtb+0xH4v8Q/Dr9iX4ayeJ9R1rwzr/hH9or9o3XvCGqXF54f8E+A/DVxNbeAvAPxO0jQ2cRwaz421\
7wTqWNZls4NOuj4PvIbXUbjW9Nktf1J/Zt+FVjonw6/ZUuf2ZLnx9+zJ+zb4Lsfilq3jX9ln4pfCbW4\
viD4pufiBJrN/Z+HPFWufFnVZ/Efwy1Pw58UNU8QaqXsJtQsdbSdIbG7uPD8mn3Uvl/8AwUr+GPj74l\
aT+zboHg69+Ol74b8dftD/AA8+Cvxm8I/CfSrLxD4Wk+DXxC8V+GvFfiz4k/EbTL3wvqX/AAjw8Mah8\
LdBk0zxOjWw0YeJNRtLpp7DWbu3f3eK6Od5jwTntDCc9LMcTSsuX2VenXdfD0244WXNCccLGtV9n7TE\
Uqdflo1ZewlCdKc/xfgzE8MZD4sZJUpYehWweAp4+hhVVVfA4jAYjDVsfh8Lic8pOjisPWzVUKNPGzo\
Zdia2Xe2xGDjLGqVHGYWHj/7eHxIm/bG+Fd18If2Jv23Ph/8AAP43fCr9sDQ/g98RL7xJ8YPiH+z1rl\
x4zh8NfFDwwvwc0y50XQl1fxhq2r+LkjfR7eytrrSdem8A6m2mXl3daLNHEVwPhH/glPaftffDzS/jL\
/wUNtfFXhr9rr4geGpfCPxgg8Aw/s9afZ2+i+DvifPqHgSTTdS8J/DzV4IPEtz4H8L+DLa71611SbxA\
dHvLjw4dUttILaRCVxYrB53m9WOYV+G8Q3XjHlSzCGCkobw9pQ566p1OVpTj7RtTUk+h+kZD4h8CeHW\
XT4TynjGnFZZia8aznwrlnE1OeISpQrzwmcPMcqWLwU8RCtLB1Y4aCqYZ0p8qbvL+7kSZ1K/Hm5/0G1\
OPPz96fxGM7f7Ubru67Pm3fel3Yl0jJ++uT5v3pbI58/721k53f2p8+Mdd8m3H3oeowib03t6q3tr53\
2WJmZoppIzHJN4iECrAPERKuGY735EofAyT+90CdQ8+7b7fZ7Wm08p+4n3bUdDJuk/4Sb96cA7SGby+\
pMeMj+bK0Iucf3kV7sP5v+nfaPz/AODof3OWEfHl/vMY8n/ltjGP7P8A+oguMbP9nHl/wbP3FLSZM6b\
pZ83P+g6ec+fn/lhpZzu/tQ5+513n7n3htzARjUh5Wb6x48jOLWden9l7sZ8Rjb/q5cdNvy/d8o+VU0\
03rWWnNFe2qwm1sGjWSKaaRY/K0gqrzr4iAkcLHJlxgZCn5RGfKpQj7OX7yO8f5u0v7v8AVn5XDYR8e\
X+8xjyf+W2MY/s//qILjGz/AGceX/Bs/cUruTH9mL5uM30g2+fjP/FO6guNn9qLu6Yx5b9Nu0Y8pSMa\
kPKzfWPHkZxazr0/svdjPiMbf9XLjpt+X7vlHyqlwb0JYpJe2pla6dYSkU0cayDw7eKWlgPiLNwnyyj\
YFyNyr/AYqIQjd/vIvSX838r/ALvT9PQDYd8+Z+8znzv+W2c5/tD/AKiDZzv/ANrPmfx7/wB+O+fM/e\
Zz53/LbOc/2h/1EGznf/tZ8z+Pf+/pSDUj5uL6x58/GbWduv8Aam3OPEZ3f6yLPXd833vNHmkg1I+bi\
+sefPxm1nbr/am3OPEZ3f6yLPXd833vNHmzyR/5+x+6X/yIBZSboLg+buzfayM+fvz/AMTLWxjP9qSZ\
+9jGT9/G35tk2kJOZP3vWWI/6/ri+mfP/IUGcZ3Z+bGd25c+c+Fbm9eK4MN7aqputVXEsU1wxkF7riy\
NvTxEQUMzqVTkqrGM7i/73QU6hmT/AE+z5mgI/cTj5RqVxI2T/wAJN8x8plwedrZkyA3mMVoRcp/vIq\
8v738y/ugRXsm2C3Pm7cX2jDPn7Mf8TLRBjP8AakePu4xkfcxt+XZDdR8eX+8xjyf+W2MY/s//AKiC4\
xs/2ceX/Bs/cY9wb1IrczXtqyi60pcRRTW7CQ3uhrG29/EQAQTIxZOCyqIxtKfurcY1IeVm+sePIzi1\
nXp/Ze7GfEY2/wCrlx02/L93yj5VuMfZQXtI/FL+btD+70/4YC6j48v95jHk/wDLbGMf2f8A9RBcY2f\
7OPL/AINn7ilZyZkvB5udur2Jx5+dm3RdKGdv9qHy8euyHH96PpRGNSHlZvrHjyM4tZ16f2XuxnxGNv\
8Aq5cdNvy/d8o+VUtjekzKl7aiSPVbA3BeKaRGZdH03c0MQ8RA2Y2GMDcBtKk70DBFIRjy1f3kdYr+b\
T3o/wB38gNh3z5n7zOfO/5bZzn+0P8AqINnO/8A2s+Z/Hv/AH9LVpMabqh83H+g6gc+fj/lhqhzu/tQ\
Y+/13j7/AN47szkg1I+bi+sefPxm1nbr/am3OPEZ3f6yLPXd833vNHm1NSN6tlqLS3tq0Itb9pFjimh\
kaPytXLKk7eIiI3KyR4c5GSx+YSDzSlGKq037SL96P83df3QP48/+CgEMV3+xX+3Bbz67N4Zguf2uf2\
nIZvE1tod14ruPD8U3/BSDxykmuweGrF5JvEk1ojG4WxhZ5bxrcW8ZZ5Bnhtc+MHxNtfH37Qngu0+NH\
7f8P7M2m+GvjB4h/Zd/ah0j9gS/8b/tWeN/i/4R+Dn7KN34N+D/AI5/Zz1H9i3wvoFj8Hbv4ifEj9oG\
Ww1bVbDwVdeKNQ+HY0X/AITrwjpeiTaz4n/ar4sf8EnPiH8UtL+MPgfVv2jPg/qHwp+K/wAXvix8Vrj\
wf4m/Zp+Iuo63Yt8Svjd4s+OkWhXvjPwf+2joEuqDTvEuswQxXVvaWBuYbCPzYCJSk/DD/gjd8XyW/w\
CM1ouGRR/xIP21uQ1w8RPP/BUTsiq3GR82SQm2Rv0epxJg/reGxeE4grYCCybLcvnClKrRkq+Eq4qdS\
bcMFWc1bERhSk6vu/vOWEOaUqv8t5XwFxPlNfiCGP8AC/KOL4Y7iPNc2oVcf9QxDjhsZClTo04qtWTh\
rT9tVpSpypyagqkajUfZec/CbUfiJrHwr+GerfF7QdK8K/FjVPh/4M1H4n+GNBmiudD8OfES98Oabc+\
NdB0a4g1nUUn0qz8Sy6nb27pqF+jQ26Mt5dAid/zu8A6T8RJtO/Zz+CniHVP2+Z/+CeHhr9qfxh8MP2\
VtL8b/ABk/ZV1P4Lar8cf2SPE/7TXii1+Fniez8HXC/HDWPgD4F1r9m28u/h1aeMde1nS7m7+GuhWer\
aPY6b4b8OSan9GfGr9gr9qTwT8ZdC+BPwa+K0/xy8eXnwxn+LXiG3n8W/tYfC7TNE8Iv4ptvB+nS2Op\
eJf+Cmdymt3za2L9buAi1a2jazki+1ia9GneZQf8Ex/+CkcNl4f0qL4cWK6L4U8Z+K/iP4T8PN+0x+0\
K3hrwp8Q/H8etReNvHnhnw1L/AMFKTYeHfGerDxr43Oo6paW8F9dP488RSXE7Sa7rbXfHn/jfwhi8fl\
+GeGqY+pw9ikq845Rn+YxvFU3UpQxGFyKpQjVfuObhOXLJJSjo4p+H30evFHhrLOOKlSg8oXHOX1Fgq\
eEz7IMthRryjiY4avUw2Kz6liHQoyrThRck6kaE63s5OVRVF9+69oOh+KdD1nwx4n0bSvEfhvxHpWo6\
D4h8Pa9p1nq+h67oer2c2n6to2s6TqEMlvqmlXVhcXEFxbzxvDPDO8UqMjMp/Hz9pb/gmR+z94D8LeO\
v2gvhH4e8K2njTwR+z78SvCHi/Tv2ifC+oftleGvGvwv0D4KJ4T8EaR4ftf2ivFur3fwm+JHgqw8DeB\
f+FfeJ9AvYE8OW/hsaLf6L4g8N3EuiC14h/wCCQn/Ba7WdX1vUdI/aU+LfhKx1S91W60zQNI+J+i3um\
eG7fUJfE0mm6bp9x4k/a1vb28tLFNe8MpG19d3NxMvgxTdTO95ftX5I/wDBUX9gb9uvQP2gv+CbHwr+\
O2t694j1n9pH4zaB4G+FEfiD4jv4v/sPxRpmt/A7wZrmo6ZPq/7Q+vQ6VJres/EbQtQ1Ym60SF7u0hj\
s7my0+1jttP8AI4g+kDwpxFgcZga3AGZ1q04VKNOti8tzLC06anGUnOOJr5bTdNS9mlClzQqYiq6VBR\
cqlo9/hv8ARZ8cOBc/wdfh3xOwmUYbEc9XE0spzLA491XSpS5YYjLVmMKeJSU5t13TrxwNOFXGXi6MH\
L+mf4M/sjfA74AeLPEPjf4YaV8QNO8SeLNKvNG8R3fin45/HX4l2esWd94z8Q/EW6mvNF+JvxI1ixfV\
W8deMPGuqi/FsL5L7x1r06XCvrmqm8Phr+zVofwy/aT/AGnP2jNJ8TatqGoftQaT8CIPE/hbUbSzNn4\
b1v4IeGvFngy31HQdUtijy6VqPhvWPD4ezuIZJrW+0W8uVv57fUYLLTOU+En7Hv8AwWM+FXw68NeAbv\
Qvht8Srnw5bX0M/jb4j3ekeJvGevS3mp6pqjy6xrd3+2O0t8sJufs1qJHkkjtLW2haWZlWSX0Cf4Cf8\
FhIZLdP+FU/s+nz55IQTp3h4EeXbX1xlR/w2N+8P+h4wuSQ+RkFN33OC8fvDGeGy+c8szrAVqKVZUY8\
McQWoVZ0pRqRvTyxU5uMalSDkrxldyj0a/L8w+i/9Iyri+IPa5vledRzyisDicTiOK8hq1cZg6OLw2L\
oRnLE5nUrQiq+CwtaMedTh7KNNvk54y+gKK8GP7P3/BYQZ/4tT+z9xu/5hmgHO3zumP2xef8AVds53D\
GdybivRX0ifDd7Qz3/AMRfiL/52HzD+hx43L/mDyL/AMSjh7/55H9MZknOoX4Zptv2O3OCjhdzT+JvM\
5OmLzhnz83GTlYsEx6Rkn8+7O6bcZtPLnY+4srp5e4f2ZwQcbcrHnssvQ5AjxqV+fKx/oNqM+Rj7s/i\
M43f2WvTb03/AC7fuxbcxaRj/fXI8r7stkMeR93cycbf7L+TOemyPdn7s3Q/hNaMVONope7Dp/16P9C\
7vuEbzDysNLx5GMK3b+y9uMWBz9yLH3ui/eyPPpaVJOdP0wlpt32PTiSUfdu8jR8cf2YOcpF/COi/Kc\
gTWETPl/u858n/AJY5zn+z/wDqHtnO/wD2s+Z/Hv8A39LSY8abpY8rH+g6eMeRj/lhpYxt/ssY+/02D\
7/3TuxPajH2cvdXxR6eUgu+5pRvMPKw0vHkYwrdv7L24xYHP3Isfe6L97I8+ldSThdOUNNsN5IGARyp\
X/hGr9fmI0xgB5YX/lonGDuI/etYRM+X+7znyf8AljnOf7P/AOoe2c7/APaz5n8e/wDf0ruPP9mN5Wc\
X0h3eRnH/ABTuoNnf/Zbbeuc+YnXduOfNYpxjzP3V8Mun91hd9zSkeY+blpefPzlW7/2puzmwGPvy5+\
71b7uD5BI8x83LS8+fnKt3/tTdnNgMfflz93q33cHyInTHmfu8Y87/AJY4xj+0P+oeuMbP9nHl/wAGz\
9wOmPM/d4x53/LHGMf2h/1D1xjZ/s48v+DZ+4jlj/KvuC77le0knMFxvaYn7ZrAO5HB2/2hrw5zpkfG\
1pOw4LfNwWi0lknzJ803M0BPyP8AeGpXDLn/AIlh580sR0+YkbWP7lMiyj2wXA8rbi+1k48jZj/iZa2\
c4/suPH3c5wPuZ3fLvh0hHzJ+66SxD/UdM30yY/5BZxnG3Hy5xt2tjyUdaMeefur4+395Du+5Su5JxB\
b7GmB+2aOBtRydv9oaCOMaZJxtWPseAvzchpbsbzDysNLx5GMK3b+y9uMWBz9yLH3ui/eyPPzb2PdBb\
jyt2b7RjjyN+f8AiZaIc4/suTP3s5wfv53fNvmuomfL/d5z5P8AyxznP9n/APUPbOd/+1nzP49/7+nG\
PsoPlV+aXRdoCu+5LG8w8rDS8eRjCt2/svbjFgc/cix97ov3sjz6VpJPuuQWm2rrGnmMFH2hhomlbNh\
/swbjjphpc9lk61YRM+X+7znyf+WOc5/s/wD6h7Zzv/2s+Z/Hv/f0rOPEl4fKxu1exGfIxv3aLpRxu/\
sseZn03zZ/uydaIRjy1fdWkV0X80Qu+5pSPMfNy0vPn5yrd/7U3ZzYDH35c/d6t93B8ilqsk40/UyGm\
3fY9RIIR927yNYzx/Zh5y8v8J6t8owRDYdMeZ+7xjzv+WOMY/tD/qHrjGz/AGceX/Bs/cUtWjzpuqDy\
s/6DqAx5Gf8Alhqgxt/ss5+502H7n3RtxAUox9rSXKrc0ei7oLvuaUjzHzctLz5+cq3f+1N2c2Ax9+X\
P3erfdwfIlWSfMnzTczQE/I/3hqVwy5/4lh580sR0+YkbWP7lKrpjzP3eMed/yxxjH9of9Q9cY2f7OP\
L/AINn7iUR8yfuuksQ/wBR0zfTJj/kFnGcbcfLnG3a2PJTKUY2XurddPNDu+58FwvKP+Cn/wApkz/ww\
XY9FYnC/tCWXl9LFv7qY45wMGXI8z70jeYeVhpePIxhW7f2XtxiwOfuRY+90X72R5/wPEmf+Cn3+rz/\
AMYF2n/LLP3v2hLXt9gbru9Pm3dZd3737zRM+X+7znyf+WOc5/s//qHtnO//AGs+Z/Hv/f8AyXCMY34\
o91f8jfGdPKkfUcTt/wDGO6/8yvCf+5CWN5h5WGl48jGFbt/Ze3GLA5+5Fj73RfvZHn/yy/8ABdLSde\
1T/goZ/wAG6l5p+l6vqNvpP7aS3WpXVnp15dQ6bF/wuf8AYXcXF9LBpQW0j8q2kbdIuNsDHYQpZ/6lU\
TPl/u858n/ljnOf7P8A+oe2c7/9rPmfx7/39LSY8abpY8rH+g6eMeRj/lhpYxt/ssY+/wBNg+/907sT\
/RZngZY/Lq2FpVY4ec6lCXPKHtElTqKo1yqdNvmUHFPmXK2pNSS5XPB+f4XhnP8AD5xjcBUzTD0KONp\
OjSxEcLOUsVgsRhYTVaeHxUYqlOtGrOHsZOrCm6SnSc1Wp6UjzHzctLz5+cq3f+1N2c2Ax9+XP3erfd\
wfIpX0k/n2fzTYa8uw/wAj4KnT/EZbf/xLOBuaTOTHyT8y4KxWHTHmfu8Y87/ljjGP7Q/6h64xs/2ce\
X/Bs/cUr6P9/YHyvu310c+R93Gm+IBnP9l/JjbjOYsbcbl27IvQpxjzP3V8Mun91nzF33NKR5j5uWl5\
8/OVbv8A2puzmwGPvy5+71b7uD5BUTpjzP3eMed/yxxjH9of9Q9cY2f7OPL/AINn7gp00lzWVtgMc6b\
ZNe3sTadamFbWKRY2sIfLWSabxEs7qp0hQHZUAc7s4TlYwuYtA6Vp/n3Z/syz3GbTy5/s6DcWV08vcP\
7H4IONuVjz2WXoYhHjUr8+Vj/QbUZ8jH3Z/EZxu/stem3pv+Xb92LbmLSMf765HlfdlshjyPu7mTjb/\
ZfyZz02R7s/dm6F1qlRTilUklyw6v8A6dv89QM2PSdNHlY0ux48jGNPg7f2XtxjSzn7kWPvdF+9kefU\
03TbKWy06WXTrWSaS1sJJJJLCFpHkaLSGZ3ZtIBZyyxkkrkkL8pJAm2ETPl/u858n/ljnOf7P/6h7Zz\
v/wBrPmfx7/39LSY8abpY8rH+g6eMeRj/AJYaWMbf7LGPv9Ng+/8AdO7E9KpU9nJ+0ldOPV9pf5L7kA\
R6Tpo8rGl2PHkYxp8Hb+y9uMaWc/cix97ov3sjz6lxptkiWKR6darFLdPHMqWEIjkjHh28YJLjSCGT9\
1EcGRR+7Vt3AlbYRM+X+7znyf8AljnOf7P/AOoe2c7/APaz5n8e/wDf0ruPP9mN5WcX0h3eRnH/ABTu\
oNnf/Zbbeuc+YnXduOfNYhUqNu9SW0ur6Rf+SAJNJ00+bnS7Hnz850+Dv/am7OdLGPvy5+71b7uD5BJ\
pOmnzc6XY8+fnOnwd/wC1N2c6WMfflz93q33cHyLrpjzP3eMed/yxxjH9of8AUPXGNn+zjy/4Nn7gdM\
eZ+7xjzv8AljjGP7Q/6h64xs/2ceX/AAbP3E+1q/8APyX3v/MDHt9NspYrhptOtZG+1arHulsISwjjv\
dcijTL6QhCLDuVRgAKCA2F3Q6C6Vp+ZP+JZZ8zQE/8AEug+8NSuGXP/ABJzz5pYjp8xI2sf3KRWUe2C\
4HlbcX2snHkbMf8AEy1s5x/ZcePu5zgfczu+XfDpCPmT910liH+o6Zvpkx/yCzjONuPlzjbtbHkoVql\
RSmlUkkpd3/MgMK402yiit2h061jb7VpUe6KwhDGOS90OKRMppDko0O1WGCCpALYbdNbj0nTR5WNLse\
PIxjT4O39l7cY0s5+5Fj73RfvZHnl7Hugtx5W7N9oxx5G/P/Ey0Q5x/ZcmfvZzg/fzu+bfNdRM+X+7z\
nyf+WOc5/s//qHtnO//AGs+Z/Hv/f26lT2UH7SV+aXV9FCwFKPSdNHlY0ux48jGNPg7f2XtxjSzn7kW\
PvdF+9kefUttNsnMyPp1q0cGq2C26vYQlIlGj6bIqw50gADfJIwCtLkuTtkJJrYRM+X+7znyf+WOc5/\
s/wD6h7Zzv/2s+Z/Hv/f0rOPEl4fKxu1exGfIxv3aLpRxu/sseZn03zZ/uydaIVKnLV/eS0irav8Ami\
ASaTpp83Ol2PPn5zp8Hf8AtTdnOljH35c/d6t93B8ipqWm2UVlqMsWnWsc0drfyRyR2EKyJIsWrsroy\
6QSrhmkIIXIJb5QQRDsOmPM/d4x53/LHGMf2h/1D1xjZ/s48v8Ag2fuKWrR503VB5Wf9B1AY8jP/LDV\
Bjb/AGWc/c6bD9z7o24gKVSo6tNOpJpyj1fdAEmk6afNzpdjz5+c6fB3/tTdnOljH35c/d6t93B8iVd\
K0/Mn/Ess+ZoCf+JdB94alcMuf+JOefNLEdPmJG1j+5Sw6Y8z93jHnf8ALHGMf2h/1D1xjZ/s48v+DZ\
+4lEfMn7rpLEP9R0zfTJj/AJBZxnG3Hy5xt2tjyUylVq2X7yW66vuvMD528Z/szfB/x58StL+JetaB4\
l0/x1D4G/4QVfE3gn4i/FD4b38nhK013SNetdCuW+HWvaZHd2g1fUZ7j97vd5BCWMwht6ij/ZX+FX7v\
F/8AG/8A5Y4x+05+03x/yDcbcfE046x4xn7qY3YTzvfDHnUrA+Vn/QboZ8jP3p/Dhxu/stuu7pv+bd9\
2XdmW6iZ8v93nPk/8sc5z/Z//AFD2znf/ALWfM/j3/v8AzquTZPOcq08qw062IbnUm6FJynNyac5ycL\
yk0knKTbaS10PSjnOcQp0qUM1xMKVGKhCKr1VGEVtGKU7Riru0Ukl2PnaP9lf4Vfu8X/xv/wCWOMftO\
ftN8f8AINxtx8TTjrHjGfupjdhPOqab+y38LpbHT5ZdS+OUk0lrYySSSftO/tOtK8jw6UzO7N8SgTIW\
KHJXOQnykhBL9KImfL/d5z5P/LHOc/2f/wBQ9s53/wC1nzP49/7+lpMeNN0seVj/AEHTxjyMf8sNLGN\
v9ljH3+mwff8AundidLJMm9nJ/wBkYW94/wDMPS7S/uD/ALazn/obYr/wfV/+TPA5P2V/hV+8zf8Axv\
8A+W2c/tOftN8/8hLO7PxNGekmc4+8+duX8mpefst/C5JrVU1L45Kst1cxzqv7Tv7ToWWMWOvS7JwPi\
Vh4/OiDEMUG5SSyncsf0o6Y8z93jHnf8scYx/aH/UPXGNn+zjy/4Nn7ilfR/v7A+V92+ujnyPu403xA\
M5/sv5MbcZzFjbjcu3ZEQyTJm3fKMK9Jf8w9L+V/3A/trOf+htiv/B9X/wCTPA5P2V/hV+8zf/G//lt\
nP7Tn7TfP/ISzuz8TRnpJnOPvPnbl/JK+iXTHmfu8Y87/AJY4xj+0P+oeuMbP9nHl/wAGz9wU6eS5Nr\
/wk4b/AMEUv/kA/trOf+htif8AwfV/+TMc3CC9vZEsbppTaxIYVfw6JFjjm8RGCVit4MpIxjCYc4I+V\
U/dGtA3S+fdj+zrzYs2niNt/hra6u6Cdl/0/aAoJ3bABx+8DDNRCTOpX483P+g2px5+fvT+Ixnb/ajd\
d3XZ82770u7EukZP31yfN+9LZHPn/e2snO7+1Pnxjrvk24+9D1Hp1pxU4/u4v3Yfzf8ATvtL5f8AB1P\
MM2O7z5W7TL4Z8jdmTw7xn+y9+d2oHpvuM5z/AKlt2cy7qmm3CJZadGljdSxLa2CLNG/h0RyRiLSB5q\
BrxcIVe4Iyi8RtuUfvQ2wj48v95jHk/wDLbGMf2f8A9RBcY2f7OPL/AINn7ilpMmdN0s+bn/QdPOfPz\
/yw0s53f2oc/c67z9z7w25gpTj7OX7uO8f5u0v739XflYCO7z5W7TL4Z8jdmTw7xn+y9+d2oHpvuM5z\
/qW3ZzLuqXFwjJYu9jdRzR3TvFE7+HTJPIfDt5mKI/bGYOJHkz8yf6lvmMp+bYR8eX+8xjyf+W2MY/s\
//qILjGz/AGceX/Bs/cUruTH9mL5uM30g2+fjP/FO6guNn9qLu6Yx5b9Nu0Y8pSE43f7uK0l/N/K/73\
X9fQAku8ebt0y+OPP24k8O84/tTZjbqA67LfGMf65duMRbSS7x5u3TL448/biTw7zj+1NmNuoDrst8Y\
x/rl24xFtuu+fM/eZz53/LbOc/2h/1EGznf/tZ8z+Pf+/HfPmfvM587/ltnOf7Q/wCog2c7/wDaz5n8\
e/8Afzzx/wCfUfvl/wDJAY9vcJHFcCGxup1+1aq4eJ/DoXzHvdckaLC3ifOsohRsD7zAqzfunGgt0uZ\
M6deYE0AX5/DXKnUrhHYZv+ggCOcYG1gGBj2qIrKTdBcHzd2b7WRnz9+f+JlrYxn+1JM/exjJ+/jb82\
ybSEnMn73rLEf9f1xfTPn/AJCgzjO7PzYzu3LnznK04qU/3cXaX97+Zf3gMK4uEkitxNY3UC/atKcvK\
/h0r5iXuhyLFhrx/naUzIuR95SWZf3rm3Hd58rdpl8M+RuzJ4d4z/Ze/O7UD033Gc5/1Lbs5l3F7Jtg\
tz5u3F9owz5+zH/Ey0QYz/akePu4xkfcxt+XZDdR8eX+8xjyf+W2MY/s/wD6iC4xs/2ceX/Bs/cW5R9\
lB+zj8Uv5u0P73X/hgKUd3nyt2mXwz5G7Mnh3jP8AZe/O7UD033Gc5/1Lbs5l3VLa4RTMy2N08kuq2B\
uI1fw6HtgdH01ZFmJvAWI2qx3NImJBvJfcF2EfHl/vMY8n/ltjGP7P/wCoguMbP9nHl/wbP3FKzkzJe\
Dzc7dXsTjz87Nui6UM7f7UPl49dkOP70fSiEo8tX93HSK/m196P978gCS7x5u3TL448/biTw7zj+1Nm\
NuoDrst8Yx/rl24xFtqalcI9lqMb2N1FE1rfo00j+HTHHGYtXHmuFvGygVLcnCNxIu1T+6C7DvnzP3m\
c+d/y2znP9of9RBs53/7WfM/j3/v6WrSY03VD5uP9B1A58/H/ACw1Q53f2oMff67x9/7x3ZnKUourTX\
s4r3o/zd1/eAJLvHm7dMvjjz9uJPDvOP7U2Y26gOuy3xjH+uXbjEW2VbpcyZ068wJoAvz+GuVOpXCOw\
zf9BAEc4wNrAMDHtUWHfPmfvM587/ltnOf7Q/6iDZzv/wBrPmfx7/38ok5k/e9ZYj/r+uL6Z8/8hQZx\
ndn5sZ3blz5z5SnGy/dR3XWXdf3gMIXCG9spHsbpZRayoIWfw6ZGjkm8OmeVS14cJGwkD5cZJ+ZX/em\
rcd3nyt2mXwz5G7Mnh3jP9l787tQPTfcZzn/UtuzmXcGTGpWA83H+g3Rx5+Puz+HBnb/ai9NvXZ8u37\
0W3EV1Hx5f7zGPJ/5bYxj+z/8AqILjGz/Zx5f8Gz9xpKcbU/3cXp/e/mf97+r+lgpR3efK3aZfDPkbs\
yeHeM/2Xvzu1A9N9xnOf9S27OZd1TTbhEstOjSxupYltbBFmjfw6I5IxFpA81A14uEKvcEZReI23KP3\
obYR8eX+8xjyf+W2MY/s/wD6iC4xs/2ceX/Bs/cUtJkzpulnzc/6Dp5z5+f+WGlnO7+1Dn7nXefufeG\
3MApx9nL93HeP83aX97+rvysBJd483bpl8ceftxJ4d5x/amzG3UB12W+MY/1y7cYi21Ly4RprYmxuka\
K6ungRn8OlriT7F4gjWKEreHa/leW/BT5eFb/VJWw758z95nPnf8ts5z/aH/UQbOd/+1nzP49/7+lfS\
fv7Aeb96+uhjz/vZ03xAcY/tT587s4xLndna27fKQnG7/dxWkv5v5X/AHuv6+gBJd483bpl8ceftxJ4\
d5x/amzG3UB12W+MY/1y7cYi2lXXfPmfvM587/ltnOf7Q/6iDZzv/wBrPmfx7/35VU5xXN+5i9us/wB\
JgUhJnUr8ebn/AEG1OPPz96fxGM7f7Ubru67Pm3fel3Yl0jJ++uT5v3pbI58/721k53f2p8+Mdd8m3H\
3oeowjbwve3sJuLoqtrFKNuq3okLXE3iJH3SLrhd0wfkUgqpbMZct+90DaQefdv9ovMyTaexP9sahtJ\
hdCpX/ifYwMfNhnH95ouozrKnzxvOSfLD7K/wCnf95dP8vMCwj48v8AeYx5P/LbGMf2f/1EFxjZ/s48\
v+DZ+4paTJnTdLPm5/0HTznz8/8ALDSznd/ahz9zrvP3PvDbmAjsoF8rFxfDb5GM6zqXGz+y8ZzrY/5\
91znH3Wzt+fyamm28Mtlp0zXF1uktbCVvL1W9jjDGLSHOyOLXNkaZhXCqQoCsAQN3k0lT9nL35WvH7K\
7S/vev4d9A2EfHl/vMY8n/AJbYxj+z/wDqILjGz/Zx5f8ABs/cUruTH9mL5uM30g2+fjP/ABTuoLjZ/\
ai7umMeW/TbtGPKUjsoF8rFxfDb5GM6zqXGz+y8ZzrY/wCfdc5x91s7fn8mpcW8MaWMIuLrbPdPE4fV\
b15No8O3ijymk1wNE/7lQWRC33lI+Z4gQVO7tOW0vsr+V/3vX/gdA2HfPmfvM587/ltnOf7Q/wCog2c\
7/wDaz5n8e/8AfjvnzP3mc+d/y2znP9of9RBs53/7WfM/j3/v6UllA3m5uL47vPzjWdS53/2pnGNbP/\
Pw2MZ+8uN3yecSWUDebm4vju8/ONZ1Lnf/AGpnGNbP/Pw2MZ+8uN3yedNqX88v/AV/8kAWUm6C4Pm7s\
32sjPn78/8AEy1sYz/akmfvYxk/fxt+bZNpCTmT971liP8Ar+uL6Z8/8hQZxndn5sZ3blz5z4Vvbwzx\
XDvcXRJutVi/darexqVjvdchX5YdcYF9sh3NyzMwZgXIEugtpADIftF5800DH/icahyU1K4nBH/E+6b\
nJOMjaRllXErFZU+ad5yT5v5V/Mv7wEV7Jtgtz5u3F9owz5+zH/Ey0QYz/akePu4xkfcxt+XZDdR8eX\
+8xjyf+W2MY/s//qILjGz/AGceX/Bs/cY9xbwwRW7pcXQIutKi/e6reyKFkvdDhb5ZtcUB9sY2twysp\
ZQHBEVuOygXysXF8NvkYzrOpcbP7LxnOtj/AJ91znH3Wzt+fybap+yh70rc0vsrtC/2v68gLqPjy/3m\
MeT/AMtsYx/Z/wD1EFxjZ/s48v8Ag2fuKVnJmS8Hm526vYnHn52bdF0oZ2/2ofLx67Icf3o+lEdlAvl\
YuL4bfIxnWdS42f2XjOdbH/Puuc4+62dvz+TUtreFzNGbi622uq2AQLqt6jgJo+msDMya5ulILsC0io\
cAKXRVVQQVPlq+9L4Vf3V/NH+9/kBsO+fM/eZz53/LbOc/2h/1EGznf/tZ8z+Pf+/patJjTdUPm4/0H\
UDnz8f8sNUOd39qDH3+u8ff+8d2ZySygbzc3F8d3n5xrOpc7/7UzjGtn/n4bGM/eXG75POqalbwxWWo\
zLcXW6O1v5V8zVb2SMsItXcb45dc2SJmZsqxKkMoJI2+cUlT9rTtKTfNH7K7r+8BsO+fM/eZz53/AC2\
znP8AaH/UQbOd/wDtZ8z+Pf8Av5RJzJ+96yxH/X9cX0z5/wCQoM4zuz82M7ty58582Sygbzc3F8d3n5\
xrOpc7/wC1M4xrZ/5+GxjP3lxu+TzpVtIAZD9ovPmmgY/8TjUOSmpXE4I/4n3Tc5JxkbSMsq4lbKSpW\
Xvy3X2V3X94CIyY1KwHm4/0G6OPPx92fw4M7f7UXpt67Pl2/ei24iuo+PL/AHmMeT/y2xjH9n/9RBcY\
2f7OPL/g2fuMcW8KXtlCLi6Ctayyndqt6ZA1vN4dRNsja4HRMD51ACsVzIUK/urcdlAvlYuL4bfIxnW\
dS42f2XjOdbH/AD7rnOPutnb8/k6SVO1O85bfyr+Z/wB71/p6BdR8eX+8xjyf+W2MY/s//qILjGz/AG\
ceX/Bs/cUtJkzpulnzc/6Dp5z5+f8AlhpZzu/tQ5+513n7n3htzAR2UC+Vi4vht8jGdZ1LjZ/ZeM51s\
f8APuuc4+62dvz+TU023hlstOma4ut0lrYSt5eq3scYYxaQ52Rxa5sjTMK4VSFAVgCBu8kSp+zl78rX\
j9ldpf3vX8O+gbDvnzP3mc+d/wAts5z/AGh/1EGznf8A7WfM/j3/AL+lfSfv7Aeb96+uhjz/AL2dN8Q\
HGP7U+fO7OMS53Z2tu3ykllA3m5uL47vPzjWdS53/ANqZxjWz/wA/DYxn7y43fJ51S8t4VmtkFxdYub\
q6ifdqt67FTZeIJv3LNrhMT7m+9Huba23DI2ZSCp3dpy2l9lfyv+96/wDA6BsO+fM/eZz53/LbOc/2h\
/1EGznf/tZ8z+Pf+/KpSWUDebm4vju8/ONZ1Lnf/amcY1s/8/DYxn7y43fJ5xVU1R9685Lb7C/+TQEp\
knOoX4Zptv2O3OCjhdzT+JvM5OmLzhnz83GTlYsEx6Rkn8+7O6bcZtPLnY+4srp5e4f2ZwQcbcrHnss\
vQ86biFL29mNvdBWtYoht0q9Mga3m8RO+6NdDDomB8jEhWK4jCFf3WgbuDz7tPs95mObT1I/sfUNoMz\
oFC/8AEhxg5+bCoP7yy9DlWoS51y0XblhtHzpeXf8AELvuXY3mHlYaXjyMYVu39l7cYsDn7kWPvdF+9\
kefS0qSc6fphLTbvsenEko+7d5Gj44/swc5SL+EdF+U5AmijvYG8rFvfHd5GM6NqXO/+y8Zzoh/5+Fz\
nP3mzu+fzqmm3EMVlp0LW91ujtbCJvL0q9kjLCLSEOySLQ9kiZmXDKCpDMQCN3nUqMvZyXsXe8fs+T8\
vT8Au+5uxvMPKw0vHkYwrdv7L24xYHP3Isfe6L97I8+ldSThdOUNNsN5IGARypX/hGr9fmI0xgB5YX/\
lonGDuI/etFHewN5WLe+O7yMZ0bUud/wDZeM50Q/8APwuc5+82d3z+dUuLiGRLGYW91tgunlcvpV6km\
0+Hbxh5SyaGWlf98pKo4b7zE/K8pIUZJv8ActaS+z/ddunp+AXfc3ZHmPm5aXnz85Vu/wDam7ObAY+/\
Ln7vVvu4PkEjzHzctLz5+cq3f+1N2c2Ax9+XP3erfdwfIzZL2BfNzb3w2+fnGjalxs/tTOMaIP8An3b\
GMfdXG35PJJL2BfNzb3w2+fnGjalxs/tTOMaIP+fdsYx91cbfk8mPYT/58v8A8Bf+XoF33JbSScwXG9\
piftmsA7kcHb/aGvDnOmR8bWk7Dgt83BaLSWSfMnzTczQE/I/3hqVwy5/4lh580sR0+YkbWP7lOdt7i\
GCK4R7e6BF1qsv7rSr2RQsl7rky/NDoagPtjO5eGVlCsQ4Bi0Fu4CZB9nvPlmgU/wDEn1DgvqVxAAP+\
JD03IQcYG0DKsuIldajJyk1RbTkvs/3l5en4Bd9GF3JOILfY0wP2zRwNqOTt/tDQRxjTJONqx9jwF+b\
kNLdjeYeVhpePIxhW7f2XtxiwOfuRY+90X72R5+FcXEM8VuiW90SbrSpf3ulXsalY73Q5m+abQ2BfbI\
Nq8szMVUlyTLbjvYG8rFvfHd5GM6NqXO/+y8Zzoh/5+FznP3mzu+fzqdCXs4Wou/NL7OtrQt0+4Lvua\
UbzDysNLx5GMK3b+y9uMWBz9yLH3ui/eyPPpWkk+65BabausaeYwUfaGGiaVs2H+zBuOOmGlz2WTrUU\
d7A3lYt747vIxnRtS53/ANl4znRD/wA/C5zn7zZ3fP51S2uIUM0ht7rbdarYFCulXruQ+j6aoEypoe6\
IkoxKyM5wQxR1ZWJChLlqXou7ire715o7advwC77m7I8x83LS8+fnKt3/ALU3ZzYDH35c/d6t93B8il\
qsk40/UyGm3fY9RIIR927yNYzx/Zh5y8v8J6t8owRDFJewL5ube+G3z840bUuNn9qZxjRB/wA+7Yxj7\
q42/J5NTUriGWy1GFbe63SWt/EvmaVexxhjFq6DfJLoeyNMwtlmAUBVJAG3ySlQkqlO9F25l9nS115e\
gXfc3ZHmPm5aXnz85Vu/9qbs5sBj78ufu9W+7g+RKsk+ZPmm5mgJ+R/vDUrhlz/xLDz5pYjp8xI2sf3\
KZEl7Avm5t74bfPzjRtS42f2pnGNEH/Pu2MY+6uNvyeTKt3ATIPs958s0Cn/iT6hwX1K4gAH/ABIem5\
CDjA2gZVlxEuUqE7L9y94/ZfdeXoO77gJJxqFgFabb9juDgI5Xcs/hny+Rpjc4VMfNzgYWXIMl2N5h5\
WGl48jGFbt/Ze3GLA5+5Fj73RfvZHn4QuIXvbKYW90VW1liO7Sr0SFribw66bY20Mu6YPzsCVUtiQOW\
/e2472BvKxb3x3eRjOjalzv/ALLxnOiH/n4XOc/ebO75/O1lRlanai9F/L/efl6fgK77mlG8w8rDS8e\
RjCt2/svbjFgc/cix97ov3sjz6WlSTnT9MJabd9j04klH3bvI0fHH9mDnKRfwjovynIE0Ud7A3lYt74\
7vIxnRtS53/wBl4znRD/z8LnOfvNnd8/nVNNuIYrLToWt7rdHa2ETeXpV7JGWEWkIdkkWh7JEzMuGUF\
SGYgEbvOFRl7OS9i73j9nyfl6fgF33N2R5j5uWl58/OVbv/AGpuzmwGPvy5+71b7uD5FK+kn8+z+abD\
Xl2H+R8FTp/iMtv/AOJZwNzSZyY+SfmXBWKKS9gXzc298Nvn5xo2pcbP7UzjGiD/AJ92xjH3Vxt+Tya\
l5cQtNbOLe6xbXV1K+7Sr1GCiy8QQ/uVbQwZX3L92Pa21d2VRcREKMk3+5a0l9n+67dPT8Au+5uyPMf\
Ny0vPn5yrd/wC1N2c2Ax9+XP3erfdwfIKzZL2BfNzb3w2+fnGjalxs/tTOMaIP+fdsYx91cbfk8kq6V\
Cr73LRl02i/8gv3YCPGpX58rH+g2oz5GPuz+Izjd/Za9NvTf8u37sW3MWkY/wB9cjyvuy2Qx5H3dzJx\
t/sv5M56bI92fuzdDmiPGpX58rH+g2oz5GPuz+Izjd/Za9NvTf8ALt+7FtzFpGP99cjyvuy2Qx5H3dz\
Jxt/sv5M56bI92fuzdDhX+OP+CH/uMCJEz5f7vOfJ/wCWOc5/s/8A6h7Zzv8A9rPmfx7/AN/S0mPGm6\
WPKx/oOnjHkY/5YaWMbf7LGPv9Ng+/907sT3UTPl/u858n/ljnOf7P/wCoe2c7/wDaz5n8e/8Af0tJj\
xpuljysf6Dp4x5GP+WGljG3+yxj7/TYPv8A3TuxPS/hy/xR/KQF1Ez5f7vOfJ/5Y5zn+z/+oe2c7/8A\
az5n8e/9/Su48/2Y3lZxfSHd5Gcf8U7qDZ3/ANltt65z5idd24581rqJny/3ec+T/wAsc5z/AGf/ANQ\
9s53/AO1nzP49/wC/pXcef7Mbys4vpDu8jOP+Kd1Bs7/7Lbb1znzE67txz5rFP4n/AIZf+ksC66Y8z9\
3jHnf8scYx/aH/AFD1xjZ/s48v+DZ+4HTHmfu8Y87/AJY4xj+0P+oeuMbP9nHl/wAGz9wOmPM/d4x53\
/LHGMf2h/1D1xjZ/s48v+DZ+4HTHmfu8Y87/ljjGP7Q/wCoeuMbP9nHl/wbP3EAUrKPbBcDytuL7WTj\
yNmP+JlrZzj+y48fdznA+5nd8u+HSEfMn7rpLEP9R0zfTJj/AJBZxnG3Hy5xt2tjyUzbKPbBcDytuL7\
WTjyNmP8AiZa2c4/suPH3c5wPuZ3fLvh0hHzJ+66SxD/UdM30yY/5BZxnG3Hy5xt2tjyUdf45/wCP/w\
BuAzb2PdBbjyt2b7RjjyN+f+Jlohzj+y5M/eznB+/nd82+a6iZ8v8Ad5z5P/LHOc/2f/1D2znf/tZ8z\
+Pf+/pXse6C3Hlbs32jHHkb8/8AEy0Q5x/ZcmfvZzg/fzu+bfNdRM+X+7znyf8AljnOf7P/AOoe2c7/\
APaz5n8e/wDf2/4UP8UvygAImfL/AHec+T/yxznP9n/9Q9s53/7WfM/j3/v6VnHiS8PlY3avYjPkY37\
tF0o43f2WPMz6b5s/3ZOtXUTPl/u858n/AJY5zn+z/wDqHtnO/wD2s+Z/Hv8A39KzjxJeHysbtXsRny\
Mb92i6Ucbv7LHmZ9N82f7snWiHw1v8K/8AS4gXXTHmfu8Y87/ljjGP7Q/6h64xs/2ceX/Bs/cUtWjzp\
uqDys/6DqAx5Gf+WGqDG3+yzn7nTYfufdG3EF10x5n7vGPO/wCWOMY/tD/qHrjGz/Zx5f8ABs/cUtWj\
zpuqDys/6DqAx5Gf+WGqDG3+yzn7nTYfufdG3EBR/i0v8UfzQF10x5n7vGPO/wCWOMY/tD/qHrjGz/Z\
x5f8ABs/cSiPmT910liH+o6Zvpkx/yCzjONuPlzjbtbHkp478RPirL4H8U+FvBWk/DTx78SfE3i7QPG\
/iiz03wO/w5sTp2heBdS8MaRrd/ql38RvGPh6BR9v8feHkhjtpZ5mAmZo4VgzFwvir9obxP4I8L+J/G\
nij9lz4+aX4Z8IaJqnijxFqZ1P9me8GmaFoEV9qurXrWlh8d5p7nyrG0uT5UETyyGAxxxSttgHhYvPM\
uwksVCtKt/sTXtpQwuKqU6fuQqvmq06M6atTnGcve92LV7HqYfJsfioYadKNL/bP4UZYjD05z9+VP3a\
dSrGo71Iyivd95ppXPoox51KwPlZ/0G6GfIz96fw4cbv7Lbru6b/m3fdl3ZluomfL/d5z5P8AyxznP9\
n/APUPbOd/+1nzP49/7+kY86lYHys/6DdDPkZ+9P4cON39lt13dN/zbvuy7sy3UTPl/u858n/ljnOf7\
P8A+oe2c7/9rPmfx7/3/uS+Gn/h/wDbpHlgiZ8v93nPk/8ALHOc/wBn/wDUPbOd/wDtZ8z+Pf8Av6Wk\
x403Sx5WP9B08Y8jH/LDSxjb/ZYx9/psH3/undie6iZ8v93nPk/8sc5z/Z//AFD2znf/ALWfM/j3/v6\
Wkx403Sx5WP8AQdPGPIx/yw0sY2/2WMff6bB9/wC6d2Jxfw5f4o/lIC66Y8z93jHnf8scYx/aH/UPXG\
Nn+zjy/wCDZ+4pX0f7+wPlfdvro58j7uNN8QDOf7L+TG3GcxY243Lt2RXXTHmfu8Y87/ljjGP7Q/6h6\
4xs/wBnHl/wbP3FK+j/AH9gfK+7fXRz5H3cab4gGc/2X8mNuM5ixtxuXbsiKfxP/DL/ANJYF10x5n7v\
GPO/5Y4xj+0P+oeuMbP9nHl/wbP3BQ6Y8z93jHnf8scYx/aH/UPXGNn+zjy/4Nn7gp0+oGObdDe3saX\
10sotYnMyp4dMjRyTeIhBEwWzOEjYRlMIMk/Kz/uhWgbVfPuz/aN5sabTzGuzw1tRUdDOq/6BtIYA7t\
hI5/eFRmohJnUr8ebn/QbU48/P3p/EYzt/tRuu7rs+bd96XdiXSMn765Pm/elsjnz/AL21k53f2p8+M\
dd8m3H3oeoK1SSnHSPww+zF/wDPt9V/W2wGbHaY8rdqd8ceRuzH4d5x/Ze/O7Tx12XGc4/1zbsYl21N\
Nt0ey06RL66iia1sHWGNPDpjjjMWkHykLWbZQKlwBl24kbcx/eldhHx5f7zGPJ/5bYxj+z/+oguMbP8\
AZx5f8Gz9xS0mTOm6WfNz/oOnnPn5/wCWGlnO7+1Dn7nXefufeG3MFKpL2cnaOjj9mPaXl5fn3YBHaY\
8rdqd8ceRuzH4d5x/Ze/O7Tx12XGc4/wBc27GJdtS4t0VLFHvrqSaS6dIpXTw6JIJB4dvMyxD7GrFzI\
kmflf8A1zfKJR8uwj48v95jHk/8tsYx/Z//AFEFxjZ/s48v+DZ+4pXcmP7MXzcZvpBt8/Gf+Kd1BcbP\
7UXd0xjy36bdox5SkKkrvSO0vsx/lfl/w/zYBJaZ83bqd8M+ftxH4d4z/amzG3Tz032+MZ/1K7c5i3E\
lpnzdup3wz5+3Efh3jP8AamzG3Tz032+MZ/1K7c5i3XXfPmfvM587/ltnOf7Q/wCog2c7/wDaz5n8e/\
8AfjvnzP3mc+d/y2znP9of9RBs53/7WfM/j3/v59pLtH/wGP8AkBj29ukkVwYb66gX7VqqBIk8OlfMS\
91yNpcrZv8AO0phdsH7ygKq/ukOgtquZM6jeYM0BX5PDXCjUrh3UZsOhgKIcZG1QWIj2sYrKTdBcHzd\
2b7WRnz9+f8AiZa2MZ/tSTP3sYyfv42/Nsm0hJzJ+96yxH/X9cX0z5/5CgzjO7PzYzu3LnznK1SSlNW\
jpL+WP8y8gMK4t0jitzNfXU6/atKQpKnh0L5j3uhxrLlrNPnWUTOuT95iGVv3qC3HaY8rdqd8ceRuzH\
4d5x/Ze/O7Tx12XGc4/wBc27GJdpeybYLc+btxfaMM+fsx/wATLRBjP9qR4+7jGR9zG35dkN1Hx5f7z\
GPJ/wCW2MY/s/8A6iC4xs/2ceX/AAbP3FupL2UHaPxS+zHtDy/4fqBSjtMeVu1O+OPI3Zj8O84/svfn\
dp467LjOcf65t2MS7altboxmVb66SSLVbAXEip4dL3IGj6a0jTA2ZKk7lU7ljTEY3gPuLbCPjy/3mMe\
T/wAtsYx/Z/8A1EFxjZ/s48v+DZ+4pWcmZLwebnbq9icefnZt0XShnb/ah8vHrshx/ej6UQqS5aukdI\
r7Mf5o+WvzAJLTPm7dTvhnz9uI/DvGf7U2Y26eem+3xjP+pXbnMW6hq9s62V7ImpTNEkN7JPDcW/h+S\
Oe2WLWC9uDFDF5RZXtgH3kKIhgHMRO4758z95nPnf8ALbOc/wBof9RBs53/AO1nzP49/wC/patJjTdU\
Pm4/0HUDnz8f8sNUOd39qDH3+u8ff+8d2Z3RqS9rT0j8S+xHuvID5+8Q2dwP2nvhAJtXuXk/4UH+03u\
eC20KCIlviL+zQYdkRtZQu1Htx99iTCDHwYwbX7VdqP8Ahl79pfGpXuT8CPi2U/d+HPlA8G+KnYDZYZ\
wYDGp2Z+VQSRHtY+jeO/hZ8LvicdPPxJ+HXgH4hHRP7T/sU+OPCnh3xadI/tMyNqP9lnXhc/YPtDWGn\
mbysecbSEv5m1PO4UfsrfsuZf8A4xx+AX+sjx/xaT4d9PtkoOP9BGRsx/ewMHcoPnP8jmOEzmrT4gw2\
GoYSdDO2+Wc6sqcqfPhaGGd6UMHUi+WVJyVqiuml7p9HgsdldOeR4jEVsRCtlHLeEKFOcZ8mKq4hWqS\
xNNq6qKLvTdmm/eR7ALdBe2Ub3100ptZXEzJ4dEixxzeHRPEoazGUkYyF8ocEfMyfvRVuO0x5W7U744\
8jdmPw7zj+y9+d2njrsuM5x/rm3YxLtDJjUrAebj/Qbo48/H3Z/Dgzt/tRem3rs+Xb96LbiK6j48v95\
jHk/wDLbGMf2f8A9RBcY2f7OPL/AINn7j6yVSSVPSOq/lj/ADPy8v6uz5wpR2mPK3anfHHkbsx+Hecf\
2Xvzu08ddlxnOP8AXNuxiXbU023R7LTpEvrqKJrWwdYY08OmOOMxaQfKQtZtlAqXAGXbiRtzH96V2Ef\
Hl/vMY8n/AJbYxj+z/wDqILjGz/Zx5f8ABs/cUtJkzpulnzc/6Dp5z5+f+WGlnO7+1Dn7nXefufeG3M\
AqkvZydo6OP2Y9peXl+fdgElpnzdup3wz5+3Efh3jP9qbMbdPPTfb4xn/UrtzmLdUvLdFmtgb66dpbq\
6SB2Tw6Gt5PsXiCRZYQtmNz+V5acB/l5Vf9U9bDvnzP3mc+d/y2znP9of8AUQbOd/8AtZ8z+Pf+/pX0\
n7+wHm/evroY8/72dN8QHGP7U+fO7OMS53Z2tu3ykKkrvSO0vsx/lfl/w/zYBJaZ83bqd8M+ftxH4d4\
z/amzG3Tz032+MZ/1K7c5i3FXXfPmfvM587/ltnOf7Q/6iDZzv/2s+Z/Hv/flVTqyXNpHp9iD/OIGOd\
Sslvb2VtRtRC1rFGsjX8PltJDN4iadFY6uwLqrguNucPy0gbEugdV0/wA+7H9p2e4TaeHH9owbgzOnl\
7j/AGxyScbctJjs0XUFFdM8JTnJNyldRit10lSXbsBFHq2mnysapY8+RjGoQd/7L24xqgx9+LH3eq/d\
wPIqabqVlFZadFLqNrHNHa2Eckcl/CsiSLFpCsjq2rkq4ZowQWyCV+YEAwlFUsJT5eXmlZtPddPl/ef\
4C6pFuPVtNPlY1Sx58jGNQg7/ANl7cY1QY+/Fj7vVfu4HkVLjUrJ0sXj1G1aKK6eSZkv4THHGfDt4oe\
XGrgKn72IZMbD94q7eREpRRHCU07qUtVbddUl282D0LcmraaPNzqljx5+c6hB2/tTdnOqHP3Jc/e6N9\
7J88k1bTR5udUsePPznUIO39qbs51Q5+5Ln73RvvZPnlFJYOlp70vvXl5eYypb6lZRRXCzajaxt9q1W\
TbLfwhjHJe65LG+H1dyUaHcynJBUkhcNtm0F1XT8yf8AEzs+JoAf+JjB946lcKuf+JwOfNDAdfmBO5T\
++copVMJTl7zlK8pJ7rrKPl5iWqT7mfcalZSxW6w6jayN9q0qTbFfwlhHHe6HLI+E1dCEWHazHIAUAl\
cLthtx6tpp8rGqWPPkYxqEHf8AsvbjGqDH34sfd6r93A8goqvqtNxjHmlZNvddeVPoMI9W00+VjVLHn\
yMY1CDv/Ze3GNUGPvxY+71X7uB5FS21KyQzO+o2qxz6rYNbs9/CElU6PpsatDnVyCN8cigqsWChG6Mg\
iiiiOFppSXNL30k9V3i+wFuTVtNHm51Sx48/OdQg7f2puznVDn7kufvdG+9k+fU1LUrKWy1GKLUbWSa\
S1v44447+FpHkaLV1VEVdXBZyyyAANkkN8xJJmKKIYWnGUZKUrxae68n28wLcmraaPNzqljx5+c6hB2\
/tTdnOqHP3Jc/e6N97J8+VdV0/Mn/Ezs+JoAf+JjB946lcKuf+JwOfNDAdfmBO5T++coqJYOlZe9LeP\
Vd4+XmBnjUrJr2ylXUbUwrayxtIt/D5ayTTeHWgRmGrqA7KhKDbnCcNGFxFbj1bTT5WNUsefIxjUIO/\
9l7cY1QY+/Fj7vVfu4HkFFX9UptRTlL3Vbdd79vNiXXyCPVtNPlY1Sx58jGNQg7/ANl7cY1QY+/Fj7v\
Vfu4HkVNN1KyistOil1G1jmjtbCOSOS/hWRJFi0hWR1bVyVcM0YILZBK/MCAYSihYSny8vNKzae66fL\
+8/wAA6pFuTVtNHm51Sx48/OdQg7f2puznVDn7kufvdG+9k+fUvNSsnmtmXUbVlhurqSdlv4SsUf2Lx\
BEXmI1fATzm25YSAs2NrFt0pRRHCU07qUtVbddUl282D0LcmraaPNzqljx5+c6hB2/tTdnOqHP3Jc/e\
6N97J88oorahgaM1K8paW6rt6A3Zr+uq/wAz/9k='
	$end 'DesignInfo'
$end 'ProjectPreview'
