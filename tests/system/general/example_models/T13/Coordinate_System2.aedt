$begin 'AnsoftProject'
	Created='Mon Feb  7 15:32:49 2022'
	Product='ElectronicsDesktop'
	FileOwnedByWorkbench=false
	$begin 'Desktop'
		Version(2021, 2)
		InfrastructureVersion(1, 0)
		$begin 'FactoryHeader'
		$end 'FactoryHeader'
	$end 'Desktop'
	UsesAdvancedFeatures=false
	NextUniqueID=0
	MoveBackwards=false
	$begin 'HFSSEnvironment'
		Version(1, 0)
	$end 'HFSSEnvironment'
	$begin 'PlanarEMEnvironment'
		Version(1, 0)
	$end 'PlanarEMEnvironment'
	$begin 'Q3DEnvironment'
		Version(1, 0)
	$end 'Q3DEnvironment'
	$begin '2DExtractorEnvironment'
		Version(1, 0)
	$end '2DExtractorEnvironment'
	$begin 'NexximEnvironment'
		Version(1, 0)
	$end 'NexximEnvironment'
	$begin 'NexximNetlistEnvironment'
		Version(1, 0)
	$end 'NexximNetlistEnvironment'
	$begin 'EmitEnvironment'
		Version(1, 0)
	$end 'EmitEnvironment'
	$begin 'Maxwell3DEnvironment'
		Version(1, 0)
	$end 'Maxwell3DEnvironment'
	$begin 'Maxwell2DEnvironment'
		Version(1, 0)
	$end 'Maxwell2DEnvironment'
	$begin 'RMxprtEnvironment'
		Version(1, 0)
	$end 'RMxprtEnvironment'
	$begin 'MaxCirEnvironment'
		Version(1, 0)
	$end 'MaxCirEnvironment'
	$begin 'SimplorerEnvironment'
		Version(1, 0)
	$end 'SimplorerEnvironment'
	$begin 'IcepakEnvironment'
		Version(1, 0)
	$end 'IcepakEnvironment'
	$begin 'MechanicalEnvironment'
		Version(1, 0)
	$end 'MechanicalEnvironment'
	$begin 'FilterDesignEnvironment'
	$end 'FilterDesignEnvironment'
	$begin 'SchematicEnvironment'
		Version(1, 0)
	$end 'SchematicEnvironment'
	$begin 'geometry3deditor'
		Version(1, 0)
	$end 'geometry3deditor'
	ReadVersion=9
	$begin 'DesignMgrEnvironment'
		CompInstCounter=1
		GPortCounter=0
		NetCounter=0
		Alias('Ieee;Simplorer Elements\\Ieee', 'Std;Simplorer Elements\\Std', 'Basic_VHDLAMS;Simplorer Elements\\Basic Elements VHDLAMS\\Basic Elements VHDLAMS', 'Digital_Elements;Simplorer Elements\\Digital Elements\\Digital Elements', 'Transformations;Simplorer Elements\\Tools\\Transformations\\Transformations', 'HEV_VHDLAMS;Simplorer Elements\\HEV VHDLAMS\\HEV VHDLAMS', 'automotive_vda;Simplorer Elements\\VDALibs VHDLAMS\\automotive_vda', 'example_boardnet;Simplorer Elements\\VDALibs VHDLAMS\\example_boardnet', 'example_ecar;Simplorer Elements\\VDALibs VHDLAMS\\example_ecar', 'fundamentals_vda;Simplorer Elements\\VDALibs VHDLAMS\\fundamentals_vda', 'hybrid_emc_vda;Simplorer Elements\\VDALibs VHDLAMS\\hybrid_emc_vda', 'megma;Simplorer Elements\\VDALibs VHDLAMS\\megma', 'modelica_rotational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_rotational', 'modelica_thermal;Simplorer Elements\\VDALibs VHDLAMS\\modelica_thermal', 'modelica_translational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_translational', 'spice2vhd;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd', 'spice2vhd_devices;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd_devices', 'aircraft_electrical_vhdlams;Simplorer Elements\\Aircraft Electrical VHDLAMS\\Aircraft Electrical VHDLAMS', 'power_system_vhdlams;Simplorer Elements\\Power System VHDLAMS\\Power System VHDLAMS')
	$end 'DesignMgrEnvironment'
	$begin 'ProjectDatasets'
		NextUniqueID=0
		MoveBackwards=false
		DatasetType='ProjectDatasetType'
		$begin 'DatasetDefinitions'
		$end 'DatasetDefinitions'
	$end 'ProjectDatasets'
	VariableOrders[0:]
	$begin 'Definitions'
		$begin 'Folders'
			Definitions(1604, 10000, 1, 1, 0, false, false)
			Materials(1604, 9500, 9, 2, 1, false, false)
			'Surface Materials'(1604, 9501, 33503, 3, 1, false, false)
			Scripts(1604, 9502, 33500, 4, 1, false, false)
			Padstacks(1604, 9003, 12, 105, 1, false, false)
			Symbols(1604, 9001, 10, 103, 1, false, false)
			Footprints(1604, 9002, 11, 104, 1, false, false)
			Bondwires(1604, 9006, 12, 108, 1, false, false)
			Components(1604, 9000, 8, 102, 1, false, false)
			Models(1604, 9004, 13, 106, 1, false, false)
			Packages(1604, 9005, 33502, 107, 1, false, false)
		$end 'Folders'
		$begin 'Materials'
			$begin 'vacuum'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=230
						Green=230
						Blue=230
						Transparency=0.949999988079071
					$end 'MatAppearanceData'
				$end 'AttachedData'
				permittivity='1'
				ModTime=1499970477
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'vacuum'
		$end 'Materials'
		$begin 'SurfaceMaterials'
		$end 'SurfaceMaterials'
		$begin 'Scripts'
		$end 'Scripts'
		$begin 'Symbols'
			$begin 'HFSSDesign1'
				ModTime=1644244322
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0.00254, 0.00254, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, 0.000423333333333333, 0.00254, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'HFSSDesign1'
		$end 'Symbols'
		$begin 'DefInfo'
			HFSSDesign1(1002, 0, 0, 0, '', 1644244322, '', 'HFSSDesign1', '', '', '', '', '', 'Design.bmp', '', 'Project', '', '', 1644244322, '', 0, 0)
		$end 'DefInfo'
		$begin 'Compdefs'
			$begin 'HFSSDesign1'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				$begin 'Properties'
					TextProp('Representation', 'SRD', '', 'HFSSDesign1')
					TextProp('Owner', 'SRD', '', 'HFSS')
				$end 'Properties'
				CompExtID=6
			$end 'HFSSDesign1'
		$end 'Compdefs'
	$end 'Definitions'
	DesignIDServer=2
	MoveBackwards=false
	$begin 'HFSSModel'
		RepRewriteV2=true
		Name='HFSSDesign1'
		DesignID=0
		'Use Advanced DC Extrapolation'=false
		'Use Power S'=false
		'Export After Simulation'=false
		'Allow Material Override'=false
		'Calculate Lossy Dielectrics'=false
		'Perform Minimal validation'=false
		$begin 'TemperatureSettings'
			IncludeTemperatureDependence=false
			EnableFeedback=false
			Temperatures(6, '22cel')
		$end 'TemperatureSettings'
		ObjsEnabledForDeformation()
		'Port Validation Settings'='Standard'
		'Save Adaptive support files'=false
		SolutionType='DrivenModal'
		$begin 'DrivenOptions'
			WithHybridAndArrays=false
			AutoOpen=false
		$end 'DrivenOptions'
		MaterialDensity=1
		MassOfTissue=1
		VoxelSize=1
		TissueObjectList=-1
		AverageSarMethod=0
		UseAutoDCThickness=true
		HaveZwaveSupport=true
		$begin 'OutputVariable'
			NextUniqueID=0
			MoveBackwards=false
		$end 'OutputVariable'
		$begin 'CableSetup'
			$begin 'CableManager'
				CableNextUniqueID=1000
				MoveBackwards=false
				Version(1, 0)
				$begin 'TDSources'
				$end 'TDSources'
				$begin 'Definitions'
				$end 'Definitions'
				$begin 'Harneses'
				$end 'Harneses'
				$begin 'HarnResults'
				$end 'HarnResults'
			$end 'CableManager'
		$end 'CableSetup'
		$begin 'ModelSetup'
			$begin 'DesignDatasets'
				NextUniqueID=0
				MoveBackwards=false
				DatasetType='DesignDatasetType'
				$begin 'DatasetDefinitions'
				$end 'DatasetDefinitions'
			$end 'DesignDatasets'
			VariableOrders[0:]
			$begin 'Editor3D Doc Preferences'
				'Plane Background'=true
				BackgroundColor1=16777215
				BackgroundColor2=0
				'Need Lights'=true
				'Ambient Light'=9671571
				'Num Lights'=4
				Light0[4: 6710886, 0, -1, -0.150000005960464]
				Light1[4: 6710886, -0.600000023841858, 0.100000001490116, -0.5]
				Light2[4: 6710886, 0.5, 0.100000001490116, -0.5]
				Light3[4: 6710886, 0.200000002980232, 0.400000005960464, 1]
				Ver=2
			$end 'Editor3D Doc Preferences'
			SnapMode=31
			WorkingCS=34
			$begin 'GeometryCore'
				BlockVersionID=3
				DataVersion=1
				NativeKernel='ACIS'
				NativeKernelVersionID=13
				Units='mm'
				InstanceID=-1
				$begin 'ValidationOptions'
					EntityCheckLevel='Strict'
					IgnoreUnclassifiedObjects=false
					SkipIntersectionChecks=false
				$end 'ValidationOptions'
				$begin 'GeometryOperations'
					BlockVersionID=2
					$begin 'AnsoftRangedIDServerManager'
						$begin 'AnsoftRangedIDServer'
							IDServerObjectTypeID=0
							IDServerRangeMin=0
							IDServerRangeMax=2146483647
							NextUniqueID=38
							MoveBackwards=false
						$end 'AnsoftRangedIDServer'
						$begin 'AnsoftRangedIDServer'
							IDServerObjectTypeID=1
							IDServerRangeMin=2146483648
							IDServerRangeMax=2146485547
							NextUniqueID=2146483654
							MoveBackwards=false
						$end 'AnsoftRangedIDServer'
					$end 'AnsoftRangedIDServerManager'
					StartBackGroundFaceID=2146483648
					$begin 'CoordinateSystems'
						$begin 'Operation'
							OperationType='CreateFaceCoordinateSystem'
							ID=34
							$begin 'FaceCSFromParameters'
								KernelVersion=13
							$end 'FaceCSFromParameters'
							ParentPartID=6
							ReferenceUDMID=-1
							$begin 'Attributes'
								Name='FaceCS1'
								UDMId=-1
							$end 'Attributes'
							$begin 'Operations'
							$end 'Operations'
							XYPlaneID=35
							PlaceHolderOperationID=33
						$end 'Operation'
					$end 'CoordinateSystems'
					$begin 'OperandCSs'
					$end 'OperandCSs'
					$begin 'SubModelDefinitions'
					$end 'SubModelDefinitions'
					$begin 'Groups'
					$end 'Groups'
					$begin 'UserDefinedModels'
					$end 'UserDefinedModels'
					$begin 'OperandUserDefinedModels'
					$end 'OperandUserDefinedModels'
					$begin 'ToplevelParts'
						$begin 'GeometryPart'
							$begin 'Attributes'
								Name='Box1'
								Flags=''
								Color='(143 175 143)'
								Transparency=0
								PartCoordinateSystem=1
								UDMId=-1
								GroupId=-1
								MaterialValue='"vacuum"'
								SurfaceMaterialValue='""'
								SolveInside=true
								ShellElement=false
								ShellElementThickness='0mm'
								IsMaterialEditable=true
								UseMaterialAppearance=false
								IsLightweight=false
								IsAlwaysHidden=false
							$end 'Attributes'
							$begin 'Operations'
								$begin 'Operation'
									OperationType='Box'
									ID=5
									ReferenceCoordSystemID=1
									$begin 'BoxParameters'
										KernelVersion=13
										XPosition='0mm'
										YPosition='0mm'
										ZPosition='0mm'
										XSize='0.6mm'
										YSize='0.6mm'
										ZSize='0.6mm'
									$end 'BoxParameters'
									ParentPartID=6
									ReferenceUDMID=-1
									IsSuppressed=false
									$begin 'OperationIdentity'
										$begin 'Topology'
											NumLumps=1
											NumShells=1
											NumFaces=6
											NumWires=0
											NumLoops=6
											NumCoedges=24
											NumEdges=12
											NumVertices=8
										$end 'Topology'
										BodyID=6
										StartFaceID=7
										StartEdgeID=13
										StartVertexID=25
										NumNewFaces=6
										NumNewEdges=12
										NumNewVertices=8
										FaceNameAndIDMap()
										EdgeNameAndIDMap()
										VertexNameAndIDMap()
									$end 'OperationIdentity'
								$end 'Operation'
								$begin 'FaceCSHolderOperation'
									OperationType='FaceCSPlaceHolder'
									ID=33
									$begin 'FaceCSParameters'
										KernelVersion=13
										PartID=6
										$begin 'Origin'
											IsAttachedToEntity=true
											EntityID=30
											FacetedBodyTriangleIndex=-1
											TriangleVertexIndex=-1
											PositionType='OnVertex'
											UParam=0
											VParam=0
											XPosition='0'
											YPosition='0'
											ZPosition='0'
										$end 'Origin'
										MoveToEnd=false
										FaceID=12
										$begin 'AxisPosn'
											IsAttachedToEntity=true
											EntityID=29
											FacetedBodyTriangleIndex=-1
											TriangleVertexIndex=-1
											PositionType='OnVertex'
											UParam=0
											VParam=0
											XPosition='0'
											YPosition='0'
											ZPosition='0'
										$end 'AxisPosn'
										WhichAxis='X'
										ZRotationAngle='0deg'
										XOffset='0mm'
										YOffset='0mm'
										AutoAxis=false
									$end 'FaceCSParameters'
									ParentPartID=6
									ReferenceUDMID=-1
								$end 'FaceCSHolderOperation'
							$end 'Operations'
						$end 'GeometryPart'
					$end 'ToplevelParts'
					$begin 'OperandParts'
					$end 'OperandParts'
					$begin 'Planes'
					$end 'Planes'
					$begin 'Points'
					$end 'Points'
					$begin 'GeometryEntityLists'
					$end 'GeometryEntityLists'
					$begin 'CachedNames'
						$begin 'allobjects'
							allobjects(-1)
						$end 'allobjects'
						$begin 'box'
							box(1)
						$end 'box'
						$begin 'facecs'
							facecs(1)
						$end 'facecs'
						$begin 'global'
							global(-1)
						$end 'global'
						$begin 'model'
							model(-1)
						$end 'model'
					$end 'CachedNames'
				$end 'GeometryOperations'
				$begin 'GeometryDependencies'
					$begin 'DependencyInformation'
						NumParents=1
						DependencyObject('GeometryBodyOperation', 5)
						DependencyObject('CoordinateSystem', 1)
					$end 'DependencyInformation'
					$begin 'DependencyInformation'
						NumParents=1
						DependencyObject('GeometryOperation', 33)
						DependencyObject('CoordinateSystem', 1)
					$end 'DependencyInformation'
					$begin 'DependencyInformation'
						NumParents=2
						DependencyObject('CoordinateSystem', 34)
						DependencyObject('GeometryBodyOperation', 5)
						DependencyObject('GeometryOperation', 33)
					$end 'DependencyInformation'
				$end 'GeometryDependencies'
			$end 'GeometryCore'
			GroupByMaterial=true
			GroupSheetByMaterial=true
			GroupCompByDefID=true
			DoNotOrganizeUnderGroup=false
			DoNotOrganizeUnderComponent=false
			OrganizeLightweight=false
			ShowGroup=true
			$begin 'LastUserInputs'
			$end 'LastUserInputs'
		$end 'ModelSetup'
		$begin '3DComponent'
			$begin 'NativeComponentVisualization'
			$end 'NativeComponentVisualization'
		$end '3DComponent'
		$begin 'BoundarySetup'
			$begin 'GlobalBoundData'
				PortImpedance='1'
				GlobalMaterialEnv='vacuum'
				UseTotalFieldFormulation=false
				HybridRegionCouplingType='TwoWayCoupled'
				'Current Source Conformance'='Auto'
				'Thin Sources'=false
			$end 'GlobalBoundData'
			$begin 'Boundaries'
				NextUniqueID=0
				MoveBackwards=false
			$end 'Boundaries'
			$begin 'ProductSpecificData'
				$begin 'SBRWedgeSettings'
					MaxWedgeAngle='135deg'
					IncludeSheetEdges=true
					ApplySourceDistFilter=false
					ApplyBoxFilter=false
				$end 'SBRWedgeSettings'
				$begin 'SBRTxRxSettings'
				$end 'SBRTxRxSettings'
				$begin 'SBRCreepingWaveSettings'
					CWRaySampleDensity=10
					CWRayCutoffDb=40
					CWCurvatureSensitivity=50
					CWAngularRayInterval=2
				$end 'SBRCreepingWaveSettings'
				$begin 'SBRBlockageSettings'
				$end 'SBRBlockageSettings'
				$begin 'PMLData'
					$begin 'PMLGroups'
					$end 'PMLGroups'
				$end 'PMLData'
				$begin 'SortOrder'
					Port[1: -1]
					Terminal[1: -1]
				$end 'SortOrder'
				'Phase Center Mode'='SinglePhaseCenter'
				'Single Phase Center'=-1
			$end 'ProductSpecificData'
		$end 'BoundarySetup'
		$begin 'ArrayDefinition'
			NextUniqueID=0
			MoveBackwards=false
		$end 'ArrayDefinition'
		$begin 'MeshSetup'
			$begin 'MeshSettings'
				$begin 'GlobalSurfApproximation'
					CurvedSurfaceApproxChoice='UseSlider'
					SliderMeshSettings=5
				$end 'GlobalSurfApproximation'
				$begin 'GlobalCurvilinear'
					Apply=false
				$end 'GlobalCurvilinear'
				$begin 'GlobalModelRes'
					UseAutoLength=true
				$end 'GlobalModelRes'
				MeshMethod='Auto'
				UseLegacyFaceterForTauVolumeMesh=false
				DynamicSurfaceResolution=false
				UseFlexMeshingForTAUvolumeMesh=false
				UseAlternativeMeshMethodsAsFallBack=true
				AllowPhiForLayeredGeometry=true
			$end 'MeshSettings'
			$begin 'MeshOperations'
				NextUniqueID=0
				MoveBackwards=false
			$end 'MeshOperations'
		$end 'MeshSetup'
		$begin 'AnalysisSetup'
			$begin 'HfssGlobalData'
				NextUniqueID=0
				MoveBackwards=false
			$end 'HfssGlobalData'
			$begin 'SolveSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'SolveSetups'
		$end 'AnalysisSetup'
		$begin 'Optimetrics'
			$begin 'OptimetricsSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'OptimetricsSetups'
		$end 'Optimetrics'
		$begin 'Solutions'
			FieldType='NoIncidentWave'
			IncludePortPostProcessing=false
			UseSpecifiedIncidentPower=false
			$begin 'Contexts'
				NextUniqueID=1
				MoveBackwards=false
			$end 'Contexts'
		$end 'Solutions'
		$begin 'PortFieldDisplay'
			$begin 'PortFieldDisplay'
				ScaleFactor=5
			$end 'PortFieldDisplay'
		$end 'PortFieldDisplay'
		$begin 'FieldsReporter'
			$begin 'FieldsCalculator'
				Line_Discretization=1000
			$end 'FieldsCalculator'
			$begin 'PlotDefaults'
				Default_SolutionId=-1
				Default_PlotFolder='Automatic'
			$end 'PlotDefaults'
			$begin 'FieldsPlotManagerID'
				NextUniqueID=0
				MoveBackwards=false
				NumQuantityType=0
				NumPlots=0
			$end 'FieldsPlotManagerID'
			$begin 'Report3dInGeomWnd'
				Report3dNum=0
			$end 'Report3dInGeomWnd'
			$begin 'Report2dInGeomWnd'
				Report2dNum=0
			$end 'Report2dInGeomWnd'
			$begin 'AntennaParametersInGeomWnd'
				AntennaParametersNum=0
			$end 'AntennaParametersInGeomWnd'
			AntennaParametersPlotTablesOrder()
		$end 'FieldsReporter'
		$begin 'RadField'
			$begin 'FarFieldSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'FarFieldSetups'
			$begin 'ArraySetup'
				UseOption='NoArray'
				$begin 'RegularArray'
					NumUCells='10'
					NumVCells='10'
					CellUDist='10mm'
					CellVDist='10mm'
					UDirnX='1'
					UDirnY='0'
					UDirnZ='0'
					VDirnX='0'
					VDirnY='1'
					VDirnZ='0'
					FirstCellPosX='0mm'
					FirstCellPosY='0mm'
					FirstCellPosZ='0mm'
					Behavior='UseScanAngle'
					ScanAnglePhi='45deg'
					ScanAngleTheta='45deg'
					UDirnPhaseShift='0deg'
					VDirnPhaseShift='0deg'
				$end 'RegularArray'
				$begin 'CustomArray'
					NumCells=0
					$begin 'Cell'
					$end 'Cell'
				$end 'CustomArray'
				$begin 'ParametricArray'
					DesignFrequency='1GHz'
					LayoutType=1
					CenterCellX='0mm'
					CenterCellY='0mm'
					CenterCellZ='0mm'
					SpecifyDesignInWavelength=false
					WidthSpacing='14.9896229mm'
					WidthSpacingInWavelength='0.05'
					Width='119.9169832mm'
					WidthInWavelength='0.4'
					LengthSpacing='14.9896229mm'
					LengthSpacingInWavelength='0.05'
					Length='89.9377374mm'
					LengthInWavelength='0.3'
					SymmetryType=0
					StaggerAngle='0deg'
					StaggerType=0
					UDirnX='1'
					UDirnY='0'
					UDirnZ='0'
					VDirnX='0'
					VDirnY='1'
					VDirnZ='0'
					WeightType=3
					EdgeTaperX_db='-200'
					CosineExp='1'
					DifferentialType=0
					Behavior='UseScanAngle'
					ScanAnglePhi='45deg'
					ScanAngleTheta='45deg'
					UDirnPhaseShift='0deg'
					VDirnPhaseShift='0deg'
				$end 'ParametricArray'
			$end 'ArraySetup'
			$begin 'NearFieldSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'NearFieldSetups'
			RadFieldComputationVersion=1.7
			RadfieldHeaderFile='RAD32F04289216442443696.tmp'
			RadPowerMethod=0
		$end 'RadField'
		$begin 'SolutionManager'
			$begin 'Version ID Map'
				V=0
				IQM=1
			$end 'Version ID Map'
			ValidationCacheHeader=''
		$end 'SolutionManager'
		$begin 'UserDefinedSolutionMgr'
			NextUniqueID=1000000
			MoveBackwards=false
		$end 'UserDefinedSolutionMgr'
		$begin 'DatasetSolutionMgr'
			NextUniqueID=2000000
			MoveBackwards=false
		$end 'DatasetSolutionMgr'
		Notes=$begin_cdata$ $end_cdata$
		$begin 'AnimationSetups'
		$end 'AnimationSetups'
		CacheHeaderFile='HDR32F04289216442443697.tmp'
	$end 'HFSSModel'
	$begin 'DataInstances'
		DesignEditor='TopLevel'
		Refdes('0', 'U1')
		$begin 'CompInstances'
			$begin 'Compinst'
				ID='0'
				Status='Status'
				CompName='HFSSDesign1'
				GatesInUse()
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '0')
				$end 'Properties'
			$end 'Compinst'
		$end 'CompInstances'
		$begin 'Instance'
			DesignEditor='HFSSDesign1'
			ID='0'
			$begin 'HfssDesignInstance'
				DesignInstanceID=1
				$begin 'WindowPosition'
					$begin 'EditorWindow'
						Circuit(Editor3d(View('View Orientation Gadget'=1, WindowPos(3, -1, -1, -8, -31, 130, 130, 1471, 560), OrientationMatrix(-0.187082901597023, -0.300000011920929, 0.474341750144958, 0, 0.561248660087585, -0.100000001490116, 0.158113896846771, 0, 4.62877292051189e-09, 0.499999970197678, 0.316227793693542, 0, 1.19209289550781e-07, 2.38418579101562e-07, -5.7486834526062, 1, 0, -1.62145113945007, 1.62145113945007, -1, 1, 4.21164131164551, 7.28572654724121), Drawings[1: 'Box1'], 'View Data'('Render Mode'=1, 'Show Ruler'=1, 'Coordinate Systems View Mode'=1, 'CS Triad View Mode'=0, 'Render Facets'=1, GridVisible=1, GridAutoAdjust=1, GridAutoExtents=1, GridType='Rect', GridStyle='Line', NumPixels=30, dXForGrid=0.2, dYForGrid=0.2, dZForGrid=0.2, dRForGrid=0.2, dThetaForGrid=10), ClipPlanes(ClipPlaneOptions(DisableWhenDrawingNewPlane=true, ForceOpqaueForUnclipped=false, ShowClipped=false, Transparency=0, HandleColor=16776960)))))
					$end 'EditorWindow'
				$end 'WindowPosition'
				$begin 'ReportSetup'
					$begin 'ReportManager'
						$begin 'Reports'
						$end 'Reports'
						NextUniqueID=0
						MoveBackwards=false
						$begin 'NextVersID'
							NextUniqueID=0
							MoveBackwards=false
						$end 'NextVersID'
					$end 'ReportManager'
					$begin 'Reports'
					$end 'Reports'
					$begin 'ReportsWindowInfoList'
					$end 'ReportsWindowInfoList'
				$end 'ReportSetup'
				$begin 'Properties'
				$end 'Properties'
				$begin 'UserDefinedDocument'
					$begin 'Data'
					$end 'Data'
				$end 'UserDefinedDocument'
			$end 'HfssDesignInstance'
		$end 'Instance'
		$begin 'SODInfo'
		$end 'SODInfo'
	$end 'DataInstances'
	$begin 'WBSystemIDToDesignInstanceIDMap'
	$end 'WBSystemIDToDesignInstanceIDMap'
	$begin 'WBSysIDSysDetails'
	$end 'WBSysIDSysDetails'
	$begin 'WBConnIDConnDetails'
	$end 'WBConnIDConnDetails'
	$begin 'WBMaterialGuidDetails'
		WBMaterialGuidMap()
	$end 'WBMaterialGuidDetails'
	$begin 'MinervaProjectSettingsBlk'
		MinervaRemoteFilePath=''
		FolderContainerString=''
	$end 'MinervaProjectSettingsBlk'
$end 'AnsoftProject'
$begin 'AllReferencedFilesForProject'
$end 'AllReferencedFilesForProject'
$begin 'ProjectPreview'
	IsEncrypted=false
	Thumbnail64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCABgAGADASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+/iiiigAr5N/ak/av0n9mqLwLpdp8PfFfxb8f/\
EDULm80b4f+ENQ8M6DqI+H3hLX/AAXp3xV8dy+IPHGr6dpKf2Jp3jjQPselvepe6zqmu6fZRC0006vr\
mifQ/jzxv4X+GXgbxn8SPG+qf2J4L+H3hTxF438X6z9i1HUv7I8L+E9IvNe1/VP7O0i0uLu/+z6TYXc\
vkWsE9xL5XlwQySsqN+EWu+KfFHxT+InjL40ePLL+zPFPjLyfDuh6CF06FvBfwe8I+JPGWo/CbwNqEO\
j313a3Hiu10zxjrGo+I7pNQ1dJvE3izWYdM1Wbw1a+H7LT/HznMv7Ow69m08TW0gnrZK3NJrslovNrd\
XPBz/N/7Kwq9k08XXdoJ6pJNc0mr7JaL+810ufeOif8FK/hXJdyL8QPgx+0r8J9GFu5tvEWt/D7wx8U\
7S91PzIhDosfh/8AZl8fePNes7iS1N7OLy70e20iNdNeCfUoby4sLW89a0r9v39inUbCC8v/ANqD4Me\
B7ubzfN8L/FrxvpHwX+IOl+XNJFH/AMJB8NPi3NoniHw158SJcWn9oaZbfbLK7ttQtPOsbq2uJfy0or\
52lxRjI6VaFOr6Xi/za79Pn3+Uo8ZY+GlbD0qy8uaD/OStv0+elj+giiv5cPD/AIC/Zj0rx3d+HPh1p\
3wt8BfGDwxZf2lM3wa1XSPhZ8bfB+nX9vHbTahZa/8AC6/0vxP4QsrzTdT+y3Etvc2sd7Y6zLZXDTWd\
5LDL9C6J4l+PXg20k0z4f/tVftCeFNGnuHv7nTtb8QeCvjjdzanLHFbzXsfiz9prwD4317T7drW1skG\
nWmq2+kQtbPcwafFeXd/c3fpU+KMPoq+EqUb6qzUtGlZ68m+vy11vp69LjLC3SxOCq0L6rlcZ3TSaev\
Jv91rO7vp/QVRX4reH/wBsL9sfwpJpx1PUfgL8YtE0e3WyfRdc8D+MfhH498YQxWjWFpqfiL4s+GfGn\
iDRNF8RiUwahqEumfDWPTdQmtp7Kw0nw/b3kM+metaF/wAFHPHOnfav+FmfsoeIZvO8j+xP+FAfGDwJ\
8T9vl+d/aX/CW/8AC6rL4Wf2HnfYfYP7M/t37Ti9+2/2X9ntP7R9Cln2V1bf7T7NvpOMl0vvbl8t99j\
1aPEuTVrL637KT6TjKPS+rtyrtvvt0v8AqfRXzV+z3+1R8Ov2jX8U6T4a0nxz4N8deA7Hw3qfjv4dfE\
Lw5HpniHwtpvjW+8WWngzUD4g8PajqnhnxZY6nF4K1+aKXw9r+sR2htGs9Uaw1SK4sIfpWvVp1adaEa\
tKaqU56pp3T/rZ9noz2aValXpwrUaiq0qiupRd0/mvPR9no9Qoor5y/ar+N8/wD+C/iPxhoUWk6j8Rt\
Yls/A3wf8Payj3dh4h+Kvi1pNP8ACiarpNnq1nfat4O0theeIfFI0uVtSsfCHg3X9WtoZP7OdaKlSFK\
E6k3ywpptvskrsKtWFGlUrVJctOknKT7JK7PiT9uv4ryfED4hab+zbotzb3HgfwLb+EfiX8bJbeO0mk\
v/AIhWnijQvG3wM+HMGtW1zO+k3GkzeFh4y8Saa0Wmap5Wq/DqaK8u/Duu63pt98v1j6Ho6aJaXcTX1\
9q2oatr3ijxb4h1vUxYrqXiLxf448S6t4z8aeJtQg0qytbKzvtT8W69rV/Lb2FpZadbSai1vp1lZWUc\
FrFsV+YZjjZ4/FVK8rqD0hFu/LFbL57u3Vs/Hc2zGeZ42riZXjB+7CLfwwWy9Xq35thVHU9SstG03Ud\
X1KdLXTtKsbvUr+6lIWO2srG3kurqeRicKiQRSMSegWr1UtS03TtZ06/0jV7Cy1XSdVsrrTdU0vUrWC\
+07UtOvoJLW9sL+yuo2ivLKa2lljlikVkkSRkdSpIPErXV9up5ytdX2623sfz+fC34iWGgfFf4S/tjX\
1l8QLTW/jV+0B4/8PfEPUNT+HHxG0rwPa/CD4jmz8K/DO1h+IereGIfD+rLp114b025jjs9RncnUZE2\
q1tKB9GWP7Rv7QdtrsXi26+Kl1qOgx/t+6j+ze/gGfwb8PoNBuPh1e3zW1qs2r2fhaPVhrNoCPIuY7+\
MuFAukuWy5/VG9+HHw81LwnaeAdR8B+DL/wAC6fFp8Nh4LvfC+h3XhOyh0mWObSorTw5PYtZ20VtNDC\
9uqQqIWiVowpUEVf8AhVfww8vyv+FceAvK/wCEv/4WF5X/AAh/h7y/+E+3+Z/wnGz+zsf8Jf5nzf2nj\
7bu58/NevPMcNUfNPC8zS5VzcsrQTbjFXirWTcU90ktdD3aua4StLnng+ZpciUuSfLTUm4xi3FWcVJx\
VtUlH3tD8yNA/aG/aBb4/wA3g3xz8RdT0bwb8QviZ8TPhp8LPE/w98N/Bz4q/CC+uksLuz8I6YmuaCi\
698PPiBo+oRRz3kevS+IIbiUmK/0bT7WGWY8V4e/bT+Ouv6J4vurjxZo/hbU/2dfgV4h0j4xTeItB8O\
W2geIf2l9Y8dX3wx+H1lqt8+lonhzTpdR0+LUA0M+naTA+qq+qTRaVDJIv6xJ8I/hlZ+K7/wCImj/Df\
4caZ8TL2O7LfEFPAvh8+K5Lq7tzbvPf6/a2sGoX0bII1mT7ZG0saeWZFBBH5Y+F/hVaaR8RPivreo+J\
rX4g/wBt/ELxzqnibWl8KN4Q0PxB8T7zVdU8LeNvsHgq+1/V2t/Dvh+y0258P6Jc3N19vMuveMyWu9I\
1awurioYnB1Izf1aEZxjBJcq1d2pvRNaxe8pX5+WUYpKyqGLwFWFSX1OEakI01FckbN3kpv4WtYPVyl\
fnUZRikrL9B/8Ag3x+JPjDXPjh+2ToXxX1PxLcfFPxd8PP2fvHmsJ4l0bw/dyaz/Y2rfFaz1fW9E8ce\
CEi0vUfCaTeNdGj0i2mh8+DTbm20rTpZNN8Phm/qWr+fz/gir4N8IeDPin+1/ZeD/CnhvwpZXHgD9lm\
8uLTw1oel6Faz3c3iP8AakhmuprfS7WJJbh4rS1VnYFmW2jUkhFA/oDr7jLpwqYKhOnBU4NOySSStJp\
2SvZX82+7b1P0bKKtOtl2GqUqapU5KVopJJWnJOyWyum1q33bd2yvw/8A+CsVjqd78bf2Rzo3inxJ4N\
1W0+F/7V91Za74YuNOW9t3Pin9k+0nhudN13TL/TNcsZLO6uUNtqWn3tvHK0V7BFDqNpZXlt+4Ffin/\
wAFTP8Akuf7J3/ZJ/2sP/Uw/ZIrDO/+RXivSH/pyJzcR/8AImxvpD/07A/N22vPjjoe/wDsX4yWviX7\
Vt+0/wDC2fht4b8Q/YvI3eT/AGB/wqm78D/Y/M86X7V9v/tTzPItvsv2LZc/a9y1+LHxu0cRQ6z4C+H\
Xji2s383Ude8L+Mtd8D63q9nvNxPFoHw58ReGtWsrTWY7ZmtraG98aJaX1xbJcXGoaRDcvHZWqK/O7R\
e8V+X5WPyppPeKfyt+VjUt/wBo/Tbdy/iz4VfGXwVpxQrBqtx4Y0H4gJcXpKmPTxo3wU8V+KdVtneBb\
mT7VcafDp6C0MUt5HczWkFxtw/tL/ABolOpfF7wJ4UvTu87QPH+vWnw58W2HzER/wBreDPHr6bq2jeb\
F5c0H2uyh+0W1zDdweZbTwyychRS5I9mvn/w5LhB9GvR/wCaf5n1BRXwZD8EPhHYSrd6D8PfDHg7Vot\
32TxH4A06P4e+LdO8xTFP/ZPjDwOdP1TSPOtnmgn+y3cP2i2uprWfzLeeaJ9y38L+LdHQ23hP41fGDw\
xp0jmeewuNd8O/El5r1gscl4Nc+NfhTxPqtojQRWyfZLe/h0+M25mis47me7muF7NdJfev8ri9mukvv\
X+Vz1j4+fE3UPBek6V4U8JXn2P4h+OftTaFePYwXdvoHhfQtT8PQePPFrPfo9qdSstM8QWMGlQywX4m\
1rXNNa60250eHVpbX5E0bSNP8P6RpWg6Rb/ZNK0TTbHSNMtfNnn+zafptrFZ2Vv59zK8k2y2hiXfI7u\
23LszEk5mjazrPjDVfEfjHxTqc2t+Jo9X174aNqs1tp1i03hr4S+OPGnhXw/5llo9jbWw1C5uTrmrX8\
qQoJNS8U3iWqWmlQ6Zpmn9LXRThyRtu3udEIKEbbt6t/12/wA+5+qP/BHr/krv7XX/AGTj9lX/ANSf9\
qyv3fr8IP8Agj1/yV39rr/snH7Kv/qT/tWV+79foGTf8i3Dekv/AEuR+pcP/wDInwfpP/05MK/FP/gq\
Z/yXP9k7/sk/7WH/AKmH7JFftZX4p/8ABUz/AJLn+yd/2Sf9rD/1MP2SKnO/+RXivSH/AKciTxH/AMi\
bG+lP/wBOwPgOiiivzw/KgooooAKKKKAPkHwH/wAg/wAUf9lY+OH/AKubx7XbVxPgP/kH+KP+ysfHD/\
1c3j2u2roOg/VH/gj1/wAld/a6/wCycfsq/wDqT/tWV+79fhB/wR6/5K7+11/2Tj9lX/1J/wBqyv3fr\
73Jv+RbhvSX/pcj9P4f/wCRPg/Sf/pyYV+Kf/BUz/kuf7J3/ZJ/2sP/AFMP2SK/ayvxT/4Kmf8AJc/2\
Tv8Ask/7WH/qYfskVOd/8ivFekP/AE5EniP/AJE2N9Kf/p2B8B0UUV+eH5UFFFFABRRRQB8g+A/+Qf4\
o/wCysfHD/wBXN49rtVS8ubzR9K0vT7nWNc8S+IvDPg7wzolnLYW95r3i3xp4g0zwn4S8P2t1q15bWd\
lc3/iXWdKs47i+urSxt2vRNe3draxzXEfFeA/+Qf4o/wCysfHD/wBXN49r9lP+CVn7O8/iPxRq37WPi\
mxsp/DGi2Xib4c/AmKebTryefxRa+JNa8IfGn4iTaRPYzy6He2Nz4aPhLw/fpc6dqTW+oePIbiyuNC1\
nRtQvfTwOEljcTChG6i9ZNdIrd/ovNo9fLcDPMMXTw8bqL1m19mC3f6K/Vo/TP8AY7/Z6i/Zl+AXg34\
b3zaTe+OriO48X/FvxDpBW5s/EvxV8VGPUPF93Y6tNotheaz4Y0+b7NoXhuTU4DqVr4V8JaFpl1LIbB\
Wr6foor9CpwjShCnBcsIJJLsloj9VpU4UadOlTjy06aUUuySsgr5e/aT/ZH+F37UEXhe88Z3/jbwr4z\
8CWniKw8B/EP4f+JBpPiLwpY+Mr7wnd+MbKPQ9dsNT8N+KLTU4fBehQSx6/oOrpaC2F1pi2OpRwX0P1\
DRRUp060JU6sFUpz3TV0/l66rs9Qq0qVenKlWpqrSno4ySafXZ9nquz1Wp+P3if/AIJUa1a/Yf8AhV3\
7VXiuHf8Aaf7c/wCF7fCnwN8Ud237P/Zn/CK/8KgvPhj/AGFjdqH27+0f7b+1Zs/sn9m/Z7n+0PCvFX\
/BPf8AbE8Kzas3h9vgR8X9C0a0a+ttU03xf4w+E3j7xgkNil9d6VoXwv8AEPg/XtD0XxCbk3Gn6fHqX\
xEj06+lggvb/VNBgu5odO/faivMq5JltS/+z+zb6xlJdLbXcfw3PHrcOZRWv/svspPrCUo9LbXcfw31\
6u/8xPiT4O/tMeB7GLVvHf7Knx40DSLi7j062vPDej+C/jffS6lNDPcw20vhT9nDxz4y1zT7RrW0vHb\
UbrS4NKieGO2nv4ry7sbe68K1v4sfDnwnql14f8c+L9I+G3imw8n+1PBXxUll+FnjzRftVvFe2X9u+A\
/iHFpmsaF9p065tLu1+2WMH2qyv7e8t/MtbiCaT+uuivPqcM4d/wALEzp/4kpflyHl1uD8LL+Bi6lL/\
Eoz/Lk/rofyr0V+82t/8E+/2Ita0u60yD9ln4J+D5bnydviP4V+BNG+DnjzTvJuIrhv7C+I/wAJ7fRf\
EHhzzliMF19g1O2+2WV1cWF151ldXNvL4V4k/wCCVPwLvr6KXwJ8U/2jfhLpC2kcdz4c8N/EPw98R7G\
91ITTtNrcuuftH+BfHOuWt3JavZwNaWurW+lImmxzQadDeT31zd+fU4axkdadaFT1vF/k1b5/I8utwh\
j4a0a9OsvPmi/yat87+R+DP7LHwe8T/tD/ABQtvgt4QuTp13r3xX+OXijxpryXlhp9x4Q+D3hj9ojUt\
N+JvizSLjU7G8in8WRWXirStO0C3/s/U0fxB4n0ubUdPbQLfWr2x/ry8B+CPC/wy8DeDPhv4I0v+xPB\
fw+8KeHfBHhDRvtuo6l/ZHhfwnpFnoOgaX/aOr3dxd3/ANn0mwtIvPup57iXyvMnmklZnb5N/Ys/Ya8\
B/sXaX8Sv+Ef8X+LPiN4x+KnjHVte8T+OfGC6VYahN4bi8ZePPFXgbwlDofhqztdMthpZ+IfieW8vob\
SGfVdV8Q6hdhLDSv7H0HRPt2vocqy/6jQbqJfWKusutl0in+L831SR9TkeV/2bh26qTxVZ3m1rZL4Yp\
9ravzfVJBRRRXqntn//2Q=='
	$begin 'DesignInfo'
		DesignName='HFSSDesign1'
		Notes=''
		Factory='HFSS'
		IsSolved=false
		'Nominal Setups'[0:]
		'Nominal Setup Types'[0:]
		'Optimetrics Setups'[0:]
		'Optimetrics Experiment Types'[0:]
		Image64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCADIAMgDASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+/iiiigAooooAKKKKACiivzu/bT/aN8X+FNc8O\
/An4MeLb7wX8Sb+x0b4hfEjxvZeH/Duqah4B+E2pv430jwqfCZ8c6Pqej3/AI58Q/ELwZcWccVzoms2\
dp4d8LeJ5b1tF1e58J3F9z4rE0sJQqYis7U6a6bvoklpdt7HNjMXRwOGq4rEStSpK7ta7eySTau29Er\
n6I0V+F2hftD/ALZXg/7V/ZP7Qfh74jf2j5H2j/hf/wAEvB3iT+xvsnneV/wiX/DP2o/C/wCxfaPtUn\
2/+1/7c8z7DZfYP7M8u9/tD1nw/wDt9/tG6BHp1n44+Bvwm+JNvY3Cy+IvGPw5+J3ib4Z6/relNdtdX\
S+Dvgt408Fa/YWfiO30uT7JaWmp/EuKw1W9sUurrV/D1rfPDpnmUuIcsq2vVlRb/ni+9t48y897W3se\
NR4pyetZSrSoN/zwfe2rjzLXfe1t7H68UV+dGif8FK/hXJdyL8QPgx+0r8J9GFu5tvEWt/D7wx8U7S9\
1PzIhDosfh/8AZl8fePNes7iS1N7OLy70e20iNdNeCfUoby4sLW89S0T/AIKCfsX6taSXOqftFfDv4b\
XCXDwJoXx2vr39nfxddwrHFIurad4K+O9j4c1fVPDkjyyQw6pbWMumz3VheWkN091Y3kMHo08dgq1vZ\
YqnNvopxv8Ade/4Hq0cyy+vb2ONpVG+inG/3Xv+B9i0UUV1HaFFFFABRRRQAUUV57p3xb+FOsfEPXPh\
FpPxO+HuqfFfwxpdvrniX4Yad408N3vxD8PaJdrZPa6xrngq21JtS0nS5V1LTjHcXFtHC4v4SrkSpuA\
PQqKKKACiiigAooooAKKKKACiiigAooooA8u+M/xd8KfAn4beIfif40TVrnRdCl0HTYNM0Gzhvtc8Qe\
JfF/iTR/Bfgrwro0N3dW9rFq2reMvEOgaZbT393Y6ZbTaslzqmoafp0V1ewfhL4bg8Tyw6r4m8fXljq\
nxL8fa9qnj34marptxqF7pdz418SzLdahpfh++1oHUJvA2i2aad4f8AC8GoSTXeneFvCWiaS80iWCGv\
cv2mPivH8efjqZNFubi4+FfwAuPGfgDw1FcR3dlH4g+Otp4k1rwT8ZfF8+i3lzKk1v4bh8Njwj4b1Vr\
bTNSjl1v4ipEuoeG9d0bUr3zCvgeIcx+tYj6rSd6GGerTvzT6vtaPwrzu766fmPFOa/XMV9ToyTw+Eb\
u0781TZvtaPwrz5nfVWKKKK+dPlQooooA8j0r4C/Bzw3fwa14J+HXhn4aeJ7Lzf7M8bfCWy/4VH8QdF\
+0wyWl7/wAI/wDEL4aPpWt+H/tOnz3dpd/Yr+D7XZX9zY3Pm2lzcQyetaJ4l+PXg20k0z4f/tVftCeF\
NGnuHv7nTtb8QeCvjjdzanLHFbzXsfiz9prwD4317T7drW1skGnWmq2+kQtbPcwafFeXd/c3bqK3pYr\
E0P4OInS/wya7dn5L7jpo4zF4f+BiqlH/AAzlHffZ+S+49X0j9rj9tLw//ZkU/i39n34g6Ton2KOa08\
TfB7xt4T8c+N9O03ylkt/EHxD8KfGR9F8NeK9StoSt3rWm+An0uzvL2S+s/CLWkcejH2LQv+CjnjnTv\
tX/AAsz9lDxDN53kf2J/wAKA+MHgT4n7fL87+0v+Et/4XVZfCz+w877D7B/Zn9u/acXv23+y/s9p/aP\
yNRXo0s+zSlb/aPaLtOMX0tvZP8AHfc9WjxLnNFr/avartOMZX0tvZS89Grve5+hWlf8FKP2cnsIG8Y\
6P8fPh54jPm/2j4O1X9nP4x+P7/R8TSC08/xd8CfCPi7wrq32iwFrdL/ZXiHUPIS9W2vvsmpQ3ljbfS\
Xw3/aW/Zy+MmuXfhj4QfH/AOCfxV8S2Gkz69feHvhv8VfAnjnXLPQ7W8sdPudZu9J8Ma9dXFvpMd/qm\
mQSXLxiFJtRgiZw80at+Mdcv4t8D+CvH+mwaN478H+FvGukW19HqdtpXi3w/pPiTTbfUoYLm1h1CCx1\
m0miivktb28jWVVEix3cqBgsjA+jR4pxMbKvhoVErfC3F+b15lr5JWPVocZ4uNliMJTqpW1i5Qfm9ed\
a+SSR/Q3rut6X4a0PWfEet3cWn6L4f0rUdb1e/nYJBZaXpVpNf393M7EBIo7SCV2JOAEJNfx6/AL40a\
R4R/aE/Z2/4KV6rpnxf03xT+1D+2D8YPBvxm1nXfgr8bNA+FOn/s3/ABrbTfh/8DLC2+MviHwJa+D/A\
BEmi3/gjQ76GHTNavJGOszRhFeynA+wB8FfANr4b1vwV4cj8YfD3wH4mtNSsvFHw7+EnxP+J3wc+HHi\
mPWrD+ydbn8UfD34V+MNH0XxHqF9oywWN7dXtjPc3lhZW1jczS2lrbwxdgD8WoPBejfDq6+J/hf4k/D\
Lw3BpltofwM+N37NX7Lvin9ntLbRio0O3vvhx8LvhF4Jv4oNLlWG80hNK8QaStnqOm2c8gurOKfT7r0\
aXFGDlZVqNSk3ba0ku+t07L/Dd9uh61DjLATsq+HqUG7bcs0r7u94uy8o3fRGLpX7aX7Ytj4st/iLqH\
x/v9a8Iwf8ABYDWv2JZPhBdfDT4O2nhO8+C+p6q1lYJdeI9O8AxeIl8TacGBtL2HV4TIqBb+O9bdI2t\
4Q/bL/bDf9sC4+GfxX+NWueGfhn8Y/jn8c/gd8AfHfwb8Efs0ftA/s36tfxaTqOm/DnQY/FXhGJPF3w\
a+MXhvWLeK81KHxdceMLW9nY2+reGtG0+3uLlvR9C+MnxA8OQ3Vv4n/Za/YX+MlvefEiD4yWMGheCNb\
/Zph8OfF63kmmufipdRahonxYXxr8SLyae3dNcQaBqemtpbs11qpv1Om+j6N+1d+y7ofxh8C+ONf8A2\
EYvhX+0f8X/AIg+CvhDb/tA2fgf9lTxGs/xS+Kuq6d4HtJ7Px/Z/FXRvH3j3wcdSvTNLKdD03W7rQNM\
nvLzRdNMVxbWvpUM5y2u4xhiUpy0UZKUXduyWqs36NnrYfiDKcS4xp4tRnKyUZKUXduySurNvsmz5R+\
Cn/BQb9s346RfEDRtK+Ivgb4eeLP2M/2OvitD+07qfxQ0v4ceEPh14h/bKtPGniz4c+A28XeKtb0u1t\
vAvh+Oz8FX/iILZ3mkaR52qxRagW0xQh+tf+CX37Vnx5+KnxB+K3wT/ai8U/FSX4x+F/hz8MviQngf4\
k/Dr4Jf2bp+ia/bPp2qeMPhp8e/2dU0zw58VPhzrGryWt1pkFx4csr2xguFht9Z8RRwXd5F9gfskfsY\
6d+zhZ/tC6x428XaN8YPiV+1L8WvFHxX+MviiD4fweBvCurS+IIpbOy8G6N4FvPE+vyWPg+x065v4o4\
L3V9SlmbVLqSaZvOKD6G+FvwF+BnwNg1i1+CnwY+E/wAHrbxDcW93r9v8Lfh14P8Ah9Brl1aJJHa3Os\
Q+EtHtF1O4ijllWN5g7IJGCkAnPqHsnrFFFFABRRRQAUUUUAFfC37d3xpvfA/w6g+DvgjWdW0T4u/Hn\
SfEWjeG9b0efUtHv/BHw30XUfCOj/Gf4naV4r0+9t38OeMdH8NeOtNtvC0tsb28Txf4q0C8l0u50Gx1\
+9036+8eeN/C/wAMvA3jP4keN9U/sTwX8PvCniLxv4v1n7FqOpf2R4X8J6Rea9r+qf2dpFpcXd/9n0m\
wu5fItYJ7iXyvLghklZUb8GtQ1/xJ8Q/H3xF+MPjW0uLDxN8SfEck+naHe3MN5ceBfhj4dM2jfCv4eI\
0GqahDplxaeGU/tbXrHT9Tv9FHjfxz4v1PRbhrHVULeLnmY/UcK403/tGIvGPkvtS+S0Xm09bNHz3Ee\
a/2dgnCk19axV4w11ivtTt5LRf3mn0aItM0zTdF03T9G0bT7HSdI0mxtNM0rStMtILDTdM02wgjtbHT\
9PsbWNIrKxhtYoo4oo1WOOONURQoAF2iivzk/KAooooAKKKKACiiigAooooAKKKKACiiigAr4QufHKf\
Fn9pf9m7WrCeK4+H/AIH/AGsv2XbD4fXNpPNc6X4zv9X/AGgvgqutfEtVuNsckUJ/tfRNAuYIFD6bPr\
Op2mo6lpPie0W19Z/aJ+ItzpOkx/DTwpqMlr4x8cWN1baxqmlX13aa58OvAl/p+s2l146sriyaP+z9f\
n1KyGmaA0lxFKNQuJ9Yt7bVLTw7q1lXgfw5s7PTvin+zTp+n2ttYWFh+1J+yLZ2NjZwRWtnZ2dr+0f8\
KYLa1tbaBFS3to4URI40UKioFUAACu7AQ/2ihNr7cbf+BLU9HLof7VhpvrUhb/wJa/p/SP7GqKKK/Uj\
9nCiiigAooooAKKK+av2rPjy/wB+FVzrWhwWOo/FDxvfXvw9+COh6vYX174d1n4s6h4T8UeJtBHi+Sx\
1Czaw8DadpHhTxBrWuypeW95Jo/he9tdGW+1640rS76KlSFGnOrUkoU6abbfRIzrVadClUrVZKFOknK\
TfRI+HP23/ivH8UPifo3wK8PXNxJ4O+B/iOz8WfGhZI7uxttc+LU3hXw14q+D/gE289yYfFXhzR/DPj\
aLxnqfn2At7XxGPh9e6Hq02p6J4hsdO+b65/wr4dg8KeH9M0GHUNW1qSyikk1HxD4hu01HxP4q1y+nl\
1DxD4w8W6skEZ1zxjrGu3eo6nq+oSIJtQ1LVbq9nzNPIx6Cvy/MMbPH4qpiJrlT0iv5YrZfq+7bdj8b\
zTMKmZ42riprljLSEf5YL4V69W+rbegUUUVxHnhRRRQAUUUUAFFFFABRRRQAUUUUAFc/4p8U6B4K0DU\
vE/ifUotK0TSoopLu7kiuLmRpLm4hs7GxsbGzhkuNV1a61C5tbWysrWKa7vbu8gtLSCa5miifoK+Fvj\
j45T4heLoPBOkTxXHgf4fatZ6tr2pWc801p4q+I+my65YN4PuY32295pPhm6j0/ULkol4h8TjT4orrT\
tT8J6laXFwg5yt06l04c8kui39DzCHUNd8UatrPj/AMW2n9n+K/Gn9l3l/oYu11K38GaZYaZBaaP4C0\
vUfOk+1abp2b6aeSJ0tL3Wtc1nV7W1sY9UNnD1/gX/AJK/+zn/ANnW/smf+tKfCusCt/wL/wAlf/Zz/\
wCzrf2TP/WlPhXXp4ZWr4dLZTh/6Uj1cJ/vWF6JVIf+lI/sRooor9KP2AKKKKACiiigAr+bj4+fta+A\
/Hf7UXxg8QeML7xlpGlfDLxN4g/Z58BjUfhv8T5PBvg/w/8ADLxNe6L8VPF+seMovD194a8NXeufFnS\
/EUmraxa6za6dceEvh34GPiCHTtV0K/jg/pHr+VS//wCSgfHz/s639r3/ANah+LtfOcS1JRwlKmm1Cr\
P3rdbK6XpfX5I+T4vqTjgKFJSahWqe9bryptLrpfW3dI9t8HfEv4cfET+0f+Ff/EDwT46/sf7H/a//A\
Ah3irQvE/8AZf8AaH2r7B/aP9iX8/2Hz/sN75Pm7fN+yS7N3lvjtq+M/FHgLwL43+w/8Jp4L8J+L/7M\
+0/2b/wlHhzR9f8A7O+2/Z/tn2H+1rOb7J532S183y9vmfZo9+di4wofhR4SsIltNBuvHfg7SYt32Tw\
54A+K3xT+HvhLTvMYyz/2T4P8D+MtP0vSPOuXmnn+y2kP2i5uprqfzLieaV/h/Zr+Zr5f8E/OPZx6Sa\
+V/wAbr8j7por43t5fjVozm60f43X/AIiuZENu9l8Uvh/4D1/w/FA5WRrqzs/hhpfgu/i1lZIokjlm1\
S4s1gnuEk0+WZ7e4tdm3+Jvx90hDbXfhr4P/EGR3M66zb+IvGnweS2RgsY0w+GZfDnjk3zo0TS/bv7W\
txKL0W/9nQ/ZftN2vZvo0/687C9m+jT/AA/Ox9X0V84Q/tGxQyrJ4i+Dfxn8L6Mu77Zrs2l+AfGMVjl\
Stvu8OfC34ia/r2o+bdGCEfYdIu/JNwJ7ryLOK4uYdm2/aY+Bzb/7a8eWvgPG37N/wtnRvEnwc/tXO7\
zv7A/4Wto2jf8ACR+R+6+1fYPtP2P7ZbfavJ+1W3mzyS/lb/EXs5/yt+mv5Hu1FUtM1PTda03T9Z0bU\
LHVtI1axtNT0rVdMu4L/TdT02/gjurHUNPvrWR4r2xmtZYpIpY2aOSORXRipBN2pICiiigAooooAKKK\
panqem6LpuoazrOoWOk6RpNjd6nquq6ndwWGm6ZpthBJdX2oahfXUiRWVjDaxSySyyMscccbO7BQSAD\
yj40/FB/hv4dt4tDTTdR8feJrmPTvB2hah9omiZFvtOt/EPizUrOzljkm8N6Fpeoi/vFa5sI7yYWWiR\
ajaalrOm+Z8S6FpEOg6TZaVFdX2oNaxsbrVdVnW71nW9SuJXutV1/Xb5Yk/tLX7/Up7u8v7plEl1eX0\
9xJmSVidnXvE1/8SPGepfEPVLa5sLT7NdeF/AmiXUd7EdJ8FWOuajcW/iCWy1WNLjSfEniVBpeo6pA1\
tp80Frp2h6NqFm19oMl5dMrspw5I+b3/AMvkdlOHJH+89/8AL5BW/wCBf+Sv/s5/9nW/smf+tKfCusC\
t/wAC/wDJX/2c/wDs639kz/1pT4V11Yf/AHih/jj/AOlI7MJ/veF/6+Q/9KR/YjRRRX6UfsAUUUUAFF\
FFABX8ql//AMlA+Pn/AGdb+17/AOtQ/F2v6q6/lUv/APkoHx8/7Ot/a9/9ah+LtfM8Tf7vhv8AG/8A0\
k+P4x/3TB/9fH/6Sx9FFFfGn5+FFFFABRRRQB5refBr4TXupXWuSfDfwVb+Iru+n1V/FWmeHNL0fxdB\
rVxO123iDT/Fuk20GpaX4kW+c3MWo211DfQXSrcw3Ec6rIL1v4J1LR3Nz4T+KXxl8MajIhgnv7j4k69\
8SUmsmKySWY0P41yeJ9KtHaeK2f7Xb2EOoRi3MMV5HbT3cNx3lFF36ofM+rv66/mc9Drnx/0yJbHTfi\
h4E1qyg3eTqfj/AOEd3rHi2581jNJ/a2o+AviT4X0m42SySRwfZNCsdltFDHP9puVmvLjobf44fFDTn\
M3if4JWGoWDIYoYfhb8UtO8V+IFvGKvHLead8SfCvgqxh0YQpcCSaLVbi7Wd7eOPT5YZJ7m0KKVoveK\
/L8rCtF7xT/D8rGzb/tKeErdCnizwV8YPBWoly0GlXHwy8RfEB7iyIUR6gNZ+CkPinSrZHnW5j+y3Go\
Q6ghtDLLZx201pPcdp4Z+OPwc8Y6tYeHfDnxP8Dal4q1JJjb+DB4k0u08cxT2lnNf6hp2o+CL65i1bS\
NZtLW2u2vrG7s4byxaynS7ggkglVPMqydc0DQvE+l3Wh+JdF0nxDol95H23R9c06z1bS7z7NcQ3lt9q\
0+/hkhuPLu7eCVN6HZJAjrhlUhOEfNf1/XUnkg+6+f6f8E+tq+O/wBo7xyniG5/4Uxok8U+nzxQX/xY\
1GznmeTTLC2u9B1fRPhpdIu23ml8R6fPcSaxbStdmPw1DJZ3+nRReKtJ1GLlbb4OfDvSt/8Awiuh3Xw\
68/b9v/4VN4i8T/CH+2PK3fZf7f8A+FYazpP/AAkP2fzLj7L9u+0fZPt1z9m8r7TceZ4X4ARxYeJpLi\
71LU7w/Ev4qafcatrmq6lr+vajbeGviJ4l8I6CdZ8Qa3d3F9rdza+F/D+h6fFPeXE862mkW0HmGOGNV\
qnTXNe97F06cVLmvfl20tr972/yO6oooroNwrf8C/8AJX/2c/8As639kz/1pT4V1gVv+Bf+Sv8A7Of/\
AGdb+yZ/60p8K62w/wDvFD/HH/0pHRhP97wv/XyH/pSP7EaKKK/Sj9gCiiigAooooAK/lUv/APkoHx8\
/7Ot/a9/9ah+Ltf1V1/Kpf/8AJQPj5/2db+17/wCtQ/F2vmeJv93w3+N/+knx/GP+6YP/AK+P/wBJY+\
iiivjT8/CiiigAooooAKKKKACiiigAooooAK+QfAf/ACD/ABR/2Vj44f8Aq5vHtfX1fIPgP/kH+KP+y\
sfHD/1c3j2tKfU0p9TtqKKK0NArf8C/8lf/AGc/+zrf2TP/AFpT4V1gVv8AgX/kr/7Of/Z1v7Jn/rSn\
wrrbD/7xQ/xx/wDSkdGE/wB7wv8A18h/6Uj+xGiiiv0o/YAooooAKKKKACv5VL//AJKB8fP+zrf2vf8\
A1qH4u1/VXX8ql/8A8lA+Pn/Z1v7Xv/rUPxdr5nib/d8N/jf/AKSfH8Y/7pg/+vj/APSWPooor40/Pw\
ooooAKKKKACiiigAooooAKKKKACvkHwH/yD/FH/ZWPjh/6ubx7X19XyD4D/wCQf4o/7Kx8cP8A1c3j2\
tKfU0p9TtqKKK0NArf8C/8AJX/2c/8As639kz/1pT4V1gVv+Bf+Sv8A7Of/AGdb+yZ/60p8K62w/wDv\
FD/HH/0pHRhP97wv/XyH/pSP7EaKKK/Sj9gCiiigAooooAK/lUv/APkoHx8/7Ot/a9/9ah+Ltf1V1/K\
pf/8AJQPj5/2db+17/wCtQ/F2vmeJv93w3+N/+knx/GP+6YP/AK+P/wBJY+iiivjT8/CiiigAooooAK\
KKKACiiigAooooAK+QfAf/ACD/ABR/2Vj44f8Aq5vHtfX1fIPgP/kH+KP+ysfHD/1c3j2tKfU0p9Ttq\
KKK0NAr6R/Y0+DOofHv9qL4ZeHoUvofCnwl17wv+0B8Rtcs0uIhpcHw38Vaf4g+FfhuHVF0q8tbPxBr\
3xX0XQmSyvkthqfhfwT41bTry31LToHX5f1O9l0+zee20vV9dv5JbWx0jw94esX1XxJ4m13U7qHTdB8\
L+GdIhYSaz4m1PWbuxsNOsov3t5e6hBbRAySqD/Un+xr+zXZ/svfBLSPBV1LbX/xD8UXNp4++NWu6dq\
d/qWh678XNU8MeG9A8Sz+FRfafZGx8F2Vh4Z0TSNEiNja3LaT4bsrnVvtet3Gp6je+vk2CeKxKqS0o4\
dqT83f3Y/ervyVup73D+XPG4yNWelDCtSfnK94x+9XfkrdT6sooor7k/SgooooAKKKKACv5VL//AJKB\
8fP+zrf2vf8A1qH4u1/VXX8ql/8A8lA+Pn/Z1v7Xv/rUPxdr5nib/d8N/jf/AKSfH8Y/7pg/+vj/APS\
WPooor40/PwooooAKKKKACiiigAooooAKKKKACvkHwH/yD/FH/ZWPjh/6ubx7X19XyD4D/wCQf4o/7K\
x8cP8A1c3j2tKfU0p9TtqKK774Q/C/xD8dPjD8Nvgv4XlvbK88ca+k3ifXtPg8+fwV8L/Dhh1b4leNW\
mbRtSh0i9i0BBpWhXmoafd6QfGHjHwxp2qx/ZdSbO9OnOrUhSguadRpJeb0OilSnXq06NOPNUqtRS82\
7I/QX/gll+zxb+PfHGtftPeLLG+OgfCnxBqPg34F/vdS0y21Xx/L4b8Q+F/i78QCFsFh8VeH9P0HxbJ\
4S0qSC/e0g1xPHNrq2lvqWkaFfWP721yngPwR4X+GXgbwZ8N/BGl/2J4L+H3hTw74I8IaN9t1HUv7I8\
L+E9Is9B0DS/7R1e7uLu/+z6TYWkXn3U89xL5XmTzSSszt1dfoWCwsMHhqdCNm1rJ/zSe7/ReSS6H6t\
l2Chl+EpYaFm46yaVuaT3f6LySQUUUV1ncFFFFABRRRQAV/Kpf/APJQPj5/2db+17/61D8Xa/qrr8sv\
GH/BLDwTrOvfEXxd4T/aH+O/hXXfHPjb4k/Eu00G/svgr4m+HGkeM/iR4u8QePtRtr3RW+Edl4g1jwS\
vivxFeGSwi8V2OpyWDNaW+u2U/l3sXi51ga+Oo0YYdJypybd3bS1tD57iHLcTmWHoU8KouVKTk+Z20t\
bTzPykor7S8T/8E1/2q/D32H/hDfiX+z58Xftn2n+0v+En0n4j/s6f8I99n+z/AGP7D/ZTfFL/AITH7\
X5915vmf2F/Z/8AZke3+0/tzf2f4prf7J37aXhvVLrRZ/2Y9X8by2Xk7vFHwr+LPwP1LwHqf2i3iu1/\
sK9+LHxB8F+IJvJWcW919v8ADOm7b20uEtftlkttqF18lUynMaXxYScv8K5+l/st/ftfTc+Gq5Hm1F2\
lgZy2XuJT3V/sOXze19Dxiiuc8SeJY/A1jFq3xL8MfEv4QaFcXcenWniX42/CP4p/BPwpfatNDPcwaF\
p/ir4r+DtH07UPEMtnaX9xFp8N1Jey22mXdzHA0FpcyRO8NeLvCnjOxl1Twf4n8PeK9Mgu5LCfUfDWt\
abrtjDfRQwXEtlLd6Xcyxx3a291ayNGWDhLmNioV1J4JU5wdpwcH5pr8zzJ0qlN2qU5U32kmn+J0NFF\
FSQFFFFABRRRQAUUUUAFfIPgP/kH+KP+ysfHD/1c3j2vr6vkHwH/AMg/xR/2Vj44f+rm8e1pT6mlPqd\
beXlnp1nd6hqF1bWFhYW095fX15PFa2dnZ2sTz3N1d3M7qlvbRwo7ySOwVFQsxABNf0Rf8E2v2a5fgt\
8GY/iZ4y0bVtG+M3x80nw54l8caXq41bTbzwh4M0u78T6r8I/hrfeFdT060fw14n0bw140v5fEkNxHd\
XqeKvEmu2i6ndaLZ6Ha2H5if8E8/wBneD4/fHiXxd4psb2f4Wfs8XvhHxlPLBNqOmweIvjxa69pPi/4\
WeHodXtLF4r+y8N22gnxN4g0xL3Tr+O41nwGbhdQ8P6zqun3f9KVfXZDgeWLxtRayuoLstnL57Lyv3P\
u+GMt5YvMaq96d400+i2lP1esV5X7hRRRX0x9iFFFFABRRRQAUUUUAFFFFABRRRQAV4n8SP2af2cvjJ\
rlp4n+L/wA+CfxV8S2GkwaDY+IfiR8KvAnjnXLPQ7W8vtQttGtNW8T6DdXFvpMd/qmpzx2ySCFJtRnl\
VA80jN7ZRSlGMlaUVJdmrkyjGatOKkuzSa/E/OjW/8Aglr+ytdaXdW/hJvjb8OvEMnk/wBn+MtE/aD+\
L/jbVNH23ET3f2Xwx8bfFnizwxqf2ixW5tX/ALT8P3/kx3z3Fl9l1CK0vbbxXxP/AMEqNatfsP8Awq7\
9qrxXDv8AtP8Abn/C9vhT4G+KO7b9n/sz/hFf+FQXnwx/sLG7UPt39o/239qzZ/ZP7N+z3P8AaH7A0V\
w1Mry+rpPCQX+FcvW/2bf1psedVybK6ytPAU1svdjyPR33hyv/AIGm2h/P9r37AH7aXh/+2Z9P0f8AZ\
9+IOk6J/aMtlNoHxW8beE/HPjfTtN857aTRfAnij4RPovhrxXqVtChttI1Hxw+l2d5epZ3fitrSOTVz\
4V4k+Dv7THgexi1bx3+yp8eNA0i4u49Otrzw3o/gv4330upTQz3MNtL4U/Zw8c+Mtc0+0a1tLx21G60\
uDSonhjtp7+K8u7G3uv6dqK4KnDuAnfkc6T8pJr/yZN/ieZV4Uyypd03Uovykmvukm/xR/IprfxY+HP\
hPVLrw/wCOfF+kfDbxTYeT/angr4qSy/Czx5ov2q3ivbL+3fAfxDi0zWNC+06dc2l3a/bLGD7VZX9ve\
W/mWtxBNJ6HX9VFfGXiT/gnh+xL4isYrK2/Zs+GngCSK7jujrPwS0u5/Z+8V3KJDPCdM1Dxn8DLzw7q\
2p+HnM6yy6ZcXsunTXNlaXU1q9zZWksHn1eGJq7o4tS30lFr01Tfzdvl28utwdNXeHxqlvZTg16K8XL\
zu+Veh+ElFfrj4k/4JU/Au+vopfAnxT/aN+EukLaRx3Phzw38Q/D3xHsb3UhNO02ty65+0f4F8c65a3\
clq9nA1pa6tb6UiabHNBp0N5PfXN38/wDir/gmF8eNEh1a9+Hnx8+GXj+O0u2Twx4N+JPwy8Q/DzV9V\
0l75Le2Xxh8ZPBnjLXLO38Q2+kSG5urvTfhzFZape2LW1tpWgW16s2ncFXh/Mad3GEayX8sl+UuV/r5\
Hl1uF82pJuFOFdL+Sa/KXK/Rb+R8HV8kfDPQPFvjK9bwB8PbK21L4h/EP49fFvwR4Fsb621O80weI9e\
+Nnj2CLWvEFtokMt8PBejWCahrniK5s4Z59P8O+GtV1MROlk4r9NPE/7GX7a/gz7D9q+B3hT4m/2l9p\
2f8KJ+M/hTWf7E+x/Z93/CVf8AC/NP+Gv2b7T9qX7D/ZP9tb/sF59v/s7ZZ/b/AKz/AOCX37EPjb4CQ\
/ED41fHrww3hX4y+MPF3xe0XwL4STxTo2uv4B+Cvjn4kW3j+5svEy+EL280m78f634q0vTrq9kttW1u\
ztNI8NaBBp8mmahP4lhvlgsoxdTExpV6EqNPRyk07WWrSls272Wuj9GLL8hx1XGQo4nDTw9JNOcpRfL\
yrVpS2cneys9He+zP0e+BfwW8F/s8/Crwn8IPh+NWfw14Uj1eZL7Xr9dS1zW9c8Ta/qvi7xd4m1q5ht\
4LddW1Xxdr2ualcw2VtZabbzao9vplhYafFbWcHrVFFfeRjGEYwilGMUkktklokvJI/TYQjThGEIqMI\
JJJbJJWSXkkFFFFUUFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUUUAFFFFABRRRQAUUU\
UAFFFFABRRRQAUUUUAf/2Q=='
	$end 'DesignInfo'
$end 'ProjectPreview'
