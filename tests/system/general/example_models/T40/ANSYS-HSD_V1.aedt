$begin 'AnsoftProject'
	Created='Tue Jun 20 11:55:55 2023'
	Product='ElectronicsDesktop'
	FileOwnedByWorkbench=false
	$begin 'Desktop'
		Version(2023, 1)
		InfrastructureVersion(1, 0)
		$begin 'FactoryHeader'
			$begin 'geometry3deditor'
				KernelVersion(2, 0)
				ProjectContainsGeometry3D='0'
			$end 'geometry3deditor'
		$end 'FactoryHeader'
	$end 'Desktop'
	UsesAdvancedFeatures=false
	NextUniqueID=0
	MoveBackwards=false
	$begin 'HFSSEnvironment'
		Version(1, 0)
	$end 'HFSSEnvironment'
	$begin 'PlanarEMEnvironment'
		Version(1, 0)
	$end 'PlanarEMEnvironment'
	$begin 'Q3DEnvironment'
		Version(1, 0)
	$end 'Q3DEnvironment'
	$begin '2DExtractorEnvironment'
		Version(1, 0)
	$end '2DExtractorEnvironment'
	$begin 'NexximEnvironment'
		Version(1, 0)
	$end 'NexximEnvironment'
	$begin 'NexximNetlistEnvironment'
		Version(1, 0)
	$end 'NexximNetlistEnvironment'
	$begin 'EmitEnvironment'
		Version(1, 0)
	$end 'EmitEnvironment'
	$begin 'Maxwell3DEnvironment'
		Version(1, 0)
	$end 'Maxwell3DEnvironment'
	$begin 'Maxwell2DEnvironment'
		Version(1, 0)
	$end 'Maxwell2DEnvironment'
	$begin 'RMxprtEnvironment'
		Version(1, 0)
	$end 'RMxprtEnvironment'
	$begin 'MaxCirEnvironment'
		Version(1, 0)
	$end 'MaxCirEnvironment'
	$begin 'SimplorerEnvironment'
		Version(1, 0)
	$end 'SimplorerEnvironment'
	$begin 'IcepakEnvironment'
		Version(1, 0)
	$end 'IcepakEnvironment'
	$begin 'MechanicalEnvironment'
		Version(1, 0)
	$end 'MechanicalEnvironment'
	$begin 'FilterDesignEnvironment'
	$end 'FilterDesignEnvironment'
	$begin 'SchematicEnvironment'
		Version(1, 0)
	$end 'SchematicEnvironment'
	$begin 'geometry3deditor'
		Version(1, 0)
	$end 'geometry3deditor'
	ReadVersion=11
	$begin 'EDB'
		Path=''
		LastUpdateTimeStamp=1687268212
	$end 'EDB'
	$begin 'DesignMgrEnvironment'
		CompInstCounter=1
		GPortCounter=0
		NetCounter=0
		Alias('Ieee;Simplorer Elements\\Ieee', 'Std;Simplorer Elements\\Std', 'Basic_VHDLAMS;Simplorer Elements\\Basic Elements VHDLAMS\\Basic Elements VHDLAMS', 'Digital_Elements;Simplorer Elements\\Digital Elements\\Digital Elements', 'Transformations;Simplorer Elements\\Tools\\Transformations\\Transformations', 'HEV_VHDLAMS;Simplorer Elements\\HEV VHDLAMS\\HEV VHDLAMS', 'automotive_vda;Simplorer Elements\\VDALibs VHDLAMS\\automotive_vda', 'example_boardnet;Simplorer Elements\\VDALibs VHDLAMS\\example_boardnet', 'example_ecar;Simplorer Elements\\VDALibs VHDLAMS\\example_ecar', 'fundamentals_vda;Simplorer Elements\\VDALibs VHDLAMS\\fundamentals_vda', 'hybrid_emc_vda;Simplorer Elements\\VDALibs VHDLAMS\\hybrid_emc_vda', 'megma;Simplorer Elements\\VDALibs VHDLAMS\\megma', 'modelica_rotational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_rotational', 'modelica_thermal;Simplorer Elements\\VDALibs VHDLAMS\\modelica_thermal', 'modelica_translational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_translational', 'spice2vhd;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd', 'spice2vhd_devices;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd_devices', 'aircraft_electrical_vhdlams;Simplorer Elements\\Aircraft Electrical VHDLAMS\\Aircraft Electrical VHDLAMS', 'power_system_vhdlams;Simplorer Elements\\Power System VHDLAMS\\Power System VHDLAMS')
	$end 'DesignMgrEnvironment'
	$begin 'ProjectDatasets'
		NextUniqueID=0
		MoveBackwards=false
		DatasetType='ProjectDatasetType'
		$begin 'DatasetDefinitions'
		$end 'DatasetDefinitions'
	$end 'ProjectDatasets'
	VariableOrders[0:]
	$begin 'Definitions'
		$begin 'Folders'
			Definitions(1604, 10000, 1, 1, 0, false, false)
			Materials(1604, 9500, 9, 2, 1, false, false)
			'Surface Materials'(1604, 9501, 33503, 3, 1, false, false)
			Scripts(1604, 9502, 33500, 4, 1, false, false)
			Padstacks(1604, 9003, 12, 105, 1, false, false)
			Symbols(1604, 9001, 10, 103, 1, false, false)
			Footprints(1604, 9002, 11, 104, 1, false, false)
			Bondwires(1604, 9006, 12, 108, 1, false, false)
			Components(1604, 9000, 8, 102, 1, false, false)
			Models(1604, 9004, 13, 106, 1, false, false)
			Packages(1604, 9005, 33502, 107, 1, false, false)
		$end 'Folders'
		$begin 'Materials'
			$begin 'copper'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				conductivity='58000000'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'copper'
			$begin 'FR4_epoxy'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal', 'Structural')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=27
						Green=110
						Blue=76
					$end 'MatAppearanceData'
				$end 'AttachedData'
				permittivity='4.4'
				dielectric_loss_tangent='0.02'
				thermal_conductivity='0.294'
				mass_density='1900'
				specific_heat='1150'
				youngs_modulus='11000000000'
				poissons_ratio='0.28'
				thermal_expansion_coefficient='1.5e-05'
				ModTime=1499970477
				Library='Materials'
				LibLocation='Project'
				ModSinceLib=true
			$end 'FR4_epoxy'
			$begin 'Megtron4'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3.77'
				dielectric_loss_tangent='0.005'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Megtron4'
			$begin 'Megtron4_2'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3.47'
				dielectric_loss_tangent='0.006'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Megtron4_2'
			$begin 'Megtron4_3'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='4.2'
				dielectric_loss_tangent='0.005'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Megtron4_3'
			$begin 'Solder Resist'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3'
				dielectric_loss_tangent='0'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Solder Resist'
		$end 'Materials'
		$begin 'SurfaceMaterials'
		$end 'SurfaceMaterials'
		$begin 'Scripts'
		$end 'Scripts'
		$begin 'Symbols'
			$begin 'CAPC0603X33X15LL03T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'COIL-1008CS_V'
			$begin 'main'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0.00254, 0.00254, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, 0.000423333333333333, 0.00254, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'main'
			$begin 'MURA-BLM15-CHIP-2_V'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'WE-Coil-PD4-S'
		$end 'Symbols'
		$begin 'DefInfo'
			CAPC0603X33X15LL03T05(1002, 0, 0, 2, '', 1687254942, '', 'CAPC0603X33X15LL03T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X05N(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X05N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X33X10LL5(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X33X10LL5', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X10LL05(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X10LL05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X23ML05T8(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X23ML05T8', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X25LL05T10(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X25LL05T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X25ML05T10(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X25ML05T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X25NL05T10(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X25NL05T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1608X08N(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1608X08N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1608X90X35ML10T15(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1608X90X35ML10T15', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC2012X12N(1002, 0, 0, 2, '', 1687254942, '', 'CAPC2012X12N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC2013X100X20NL20(1002, 0, 0, 2, '', 1687254942, '', 'CAPC2013X100X20NL20', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC3216X180X20ML20(1002, 0, 0, 2, '', 1687254942, '', 'CAPC3216X180X20ML20', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC3216X180X55ML20T25(1002, 0, 0, 2, '', 1687254942, '', 'CAPC3216X180X55ML20T25', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC3216X190X55ML30T25(1002, 0, 0, 2, '', 1687254942, '', 'CAPC3216X190X55ML30T25', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPMP7343X31N(1002, 0, 0, 2, '', 1687254942, '', 'CAPMP7343X31N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'COIL-1008CS_V'(1002, 0, 0, 2, '', 1687254942, '', 'COIL-1008CS_V', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'MURA-BLM15-CHIP-2_V'(1002, 0, 0, 2, '', 1687254942, '', 'MURA-BLM15-CHIP-2_V', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'MURA-BLM15AG221SN1x_V'(1002, 0, 0, 2, '', 1687254942, '', 'MURA-BLM15AG221SN1x_V', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X35X25NL8T10(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X35X25NL8T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25LL05T05(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25LL05T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25ML05T05(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25ML05T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25NL05T05(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25NL05T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25NL5T10(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25NL5T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1608X05N(1002, 0, 0, 2, '', 1687254942, '', 'RESC1608X05N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'SMD-0603'(1002, 0, 0, 2, '', 1687254942, '', 'SMD-0603', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'WE-Coil-744301047'(1002, 0, 0, 2, '', 1687254942, '', 'WE-Coil-744301047', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'WE-Coil-PD4-S'(1002, 0, 0, 2, '', 1687254942, '', 'WE-Coil-PD4-S', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			main(1002, 0, 16, 0, '', 1687254942, '', 'main', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
		$end 'DefInfo'
		$begin 'Compdefs'
			$begin 'CAPC0603X33X15LL03T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 0, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 1, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 2, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 3, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 4, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 5, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 6, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 7, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 8, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 9, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 10, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 11, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 12, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 13, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 14, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 15, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 16, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 17, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 18, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 19, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 20, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 21, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 22, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 23, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 24, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 25, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 26, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 27, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 28, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 29, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 30, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 31, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 32, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 33, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'COIL-1008CS_V'
			$begin 'MURA-BLM15-CHIP-2_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 34, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 35, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 36, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 37, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 38, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 39, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 40, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 41, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 42, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 43, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 44, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 45, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 46, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 47, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 48, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 49, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 50, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 51, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 52, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 53, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 54, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 55, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'WE-Coil-PD4-S'
			$begin 'main'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				$begin 'Properties'
					TextProp('Representation', 'SD', '', 'main')
				$end 'Properties'
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'main'
		$end 'Compdefs'
	$end 'Definitions'
	DesignIDServer=2
	MoveBackwards=false
	$begin 'PlanarEMCircuit'
		RepRewriteV2=true
		Name='main'
		DesignID=0
		$begin 'Circuit'
			ComponentName='main'
			AutoFP=''
			$begin 'DesignDatasets'
				NextUniqueID=0
				MoveBackwards=false
				DatasetType='DesignDatasetType'
				$begin 'DatasetDefinitions'
				$end 'DatasetDefinitions'
			$end 'DesignDatasets'
			VariableOrders[0:]
			$begin 'Net'
				NetName='+VREFDDR4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_AVDDL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_AVDLL_PLL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_DVDDL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.8V_DVDDH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='12V-In'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1V0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='2V5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='3.3V_AVDDH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='5V'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='A10_GNDSENSE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AVCC_1V3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLOCK_I2C_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLOCK_I2C_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ACT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BG0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CAS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CKE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CLK_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CLK_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CSN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ20'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ21'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ22'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ23'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ24'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ25'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ26'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ27'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ28'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ29'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ30'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ31'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ32'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ33'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ34'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ35'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ36'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ37'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ38'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ39'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ40'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ41'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ42'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ43'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ44'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ45'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ47'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ48'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ49'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ50'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ51'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ52'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ53'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ54'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ55'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ56'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ57'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ58'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ59'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ60'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ61'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ62'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ63'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS4_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS4_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS5_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS5_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS6_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS6_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS7_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS7_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ODT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_PAR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_RAS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_RESETN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_WEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_3V3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_GTX_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_MDC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_MDIO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RX_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RX_DV'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TX_EN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GND_DP'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TCK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TDI'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TDO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TMS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TRST'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH01_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH01_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH02_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH02_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH03_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH03_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH04_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH04_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH05_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH05_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH06_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH06_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH07_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH07_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH08_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH08_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH09_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH09_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH10_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH10_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH11_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH11_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH12_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH12_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC10_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC10_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC177_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC178_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC179_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC180_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC18_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC19_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC19_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC25_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC26_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC26_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC271_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC291_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC33_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC34_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC34_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC35_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC42_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC43_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC50_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC50_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC9_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetD3_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC2_5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ3_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR100_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR102_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR104_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR105_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR106_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR108_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR113_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR114_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR115_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR116_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR116_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR117_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR119_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR11_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR120_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR121_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR122_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR123_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR124_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR12_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR13_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR1_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR22_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR24_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR25_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR26_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR34_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR65_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR66_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR82_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR83_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR8_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR99_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU13_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU13_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AP13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AV11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AW11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AW13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU9_46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_CLKREQ_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_REFCLK_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_REFCLK_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RST_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_SMB_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_SMB_DATA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_USB_D_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_USB_D_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_W_DISABLE_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_WAKE_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PDEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PLL_1V8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK0_FMCB_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK0_FMCB_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK_DP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK_DP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA__Mod_ABS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RS0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RS1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Rx_LOS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Tx_Disable'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Tx_Fault'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_TX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_TX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_VCCR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_VCCT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD4_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD4_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_D_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_D_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSTX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSTX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_VBUS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VDD_DDR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
		$end 'Circuit'
		$begin 'Layout'
			BlackBox=false
			DefUnits='mm'
			NIdx=5955
			ActLyr='1_Top'
			Tol(1e-08, 1e-08, 1e-12)
			$begin 'HfssExportInfo'
				ScriptFileName=''
				HfssFileName=''
				Version=2
				ExtentType='PolygonExtent'
				BasePolygon='poly_5949'
				BasePolygonEDBUId=5949
				DielExtentType='BboxExtent'
				DielBasePolygon=''
				DielBasePolygonEDBUId=-1
				DielExt(Ext='0', Dim=false)
				HonorUserDiel=true
				TruncAtGnd=false
				AirHorExt(Ext='0.15', Dim=false)
				AirPosZExt(Ext='0.15', Dim=false)
				AirNegZExt(Ext='0.15', Dim=false)
				SyncZExt=true
				OpenRegionType='Radiation'
				UseRadBound=true
				PMLVisible=false
				OperFreq='5GHz'
				RadLvl=0
				UseStackupForZExtFact=false
				Smooth=true
			$end 'HfssExportInfo'
		$end 'Layout'
		$begin 'Rule Set'
			$begin 'Data'
			$end 'Data'
			$begin 'DRCSolutionMgr'
			$end 'DRCSolutionMgr'
		$end 'Rule Set'
		$begin 'Workflow'
			WorkflowName=''
			SpecName=''
			TemplateName=''
			LibLoc=-2
		$end 'Workflow'
		$begin 'Port'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Port'
		$begin 'Boundary'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Boundary'
		$begin 'Cavity'
			$begin 'Data'
			$end 'Data'
		$end 'Cavity'
		$begin 'Via'
			$begin 'Data'
			$end 'Data'
		$end 'Via'
		$begin 'LayoutVia'
			$begin 'Data'
			$end 'Data'
		$end 'LayoutVia'
		$begin 'Source'
			$begin 'Data'
			$end 'Data'
		$end 'Source'
		$begin 'Voltage Probe'
			$begin 'Data'
			$end 'Data'
		$end 'Voltage Probe'
		$begin 'DC Terminal'
			$begin 'Data'
			$end 'Data'
		$end 'DC Terminal'
		$begin 'CircuitSources'
			$begin 'Data'
			$end 'Data'
		$end 'CircuitSources'
		$begin 'NexximPorts'
			$begin 'Data'
			$end 'Data'
			$begin 'DiffPairs'
			$end 'DiffPairs'
		$end 'NexximPorts'
		$begin 'SortOrder'
		$end 'SortOrder'
		$begin 'NexximMultiComponentContainers'
			$begin 'Data'
			$end 'Data'
		$end 'NexximMultiComponentContainers'
		$begin 'ComponentConfigurationData'
			$begin 'EnabledPorts'
			$end 'EnabledPorts'
			$begin 'EnabledMultipleComponents'
			$end 'EnabledMultipleComponents'
			$begin 'EnabledAnalyses'
			$end 'EnabledAnalyses'
		$end 'ComponentConfigurationData'
		$begin 'Properties'
		$end 'Properties'
		$begin 'CustomSimSetups'
			$begin 'Data'
			$end 'Data'
		$end 'CustomSimSetups'
		$begin 'RadSetup'
			$begin 'Data'
			$end 'Data'
		$end 'RadSetup'
		$begin 'Setup'
			$begin 'Data'
			$end 'Data'
		$end 'Setup'
		$begin 'AnalysisOptionBlocks'
		$end 'AnalysisOptionBlocks'
		$begin 'EM properties'
			$begin 'Data'
			$end 'Data'
		$end 'EM properties'
		$begin 'OutputVariable'
			NextUniqueID=0
			MoveBackwards=false
		$end 'OutputVariable'
		$begin 'Optimetrics'
			$begin 'OptimetricsSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'OptimetricsSetups'
		$end 'Optimetrics'
		$begin 'FieldsReporter'
			$begin 'FieldsCalculator'
				Line_Discretization=1000
			$end 'FieldsCalculator'
			$begin 'PlotDefaults'
				Default_SolutionId=-1
				Default_PlotFolder='Automatic'
			$end 'PlotDefaults'
			$begin 'FieldsPlotManagerID'
				NextUniqueID=0
				MoveBackwards=false
				NumQuantityType=0
				NumPlots=0
			$end 'FieldsPlotManagerID'
			$begin 'Report3dInGeomWnd'
				Report3dNum=0
			$end 'Report3dInGeomWnd'
			$begin 'Report2dInGeomWnd'
				Report2dNum=0
			$end 'Report2dInGeomWnd'
			$begin 'AntennaParametersInGeomWnd'
				AntennaParametersNum=0
			$end 'AntennaParametersInGeomWnd'
			AntennaParametersPlotTablesOrder()
			$begin 'EntitySelectionCache'
			$end 'EntitySelectionCache'
		$end 'FieldsReporter'
		$begin 'SolutionManager'
			$begin 'SimDataExtractors'
				$begin 'Version ID Map'
					V=1
				$end 'Version ID Map'
			$end 'SimDataExtractors'
		$end 'SolutionManager'
		$begin 'InterfaceOptions'
			SchematicEnabled=false
			SaveBeforeSolving=true
		$end 'InterfaceOptions'
		$begin 'AdvancedSettings'
			ComputeBothEvenAndOddCPWModes=false
			CausalMaterials=true
			MeshingMethod='Phi'
			EnableDesignIntersectionCheck=true
			UseAlternativeMeshMethodsAsFallBack=true
			CircuitSparamDefinition=false
			CircuitIntegrationType='FFT'
			BroadbandFreqOption='AutoMaxFreq'
			BroadbandMaxNumFreq=5
			SaveADP=false
			UseAdvancedDCExtrap=false
			ModeOption='General mode'
			PhiMesherDeltaZRatio=100000
			SpiceType='TouchStone1.0'
			EnforcePassivity=false
			EnforceCausality=false
			UseCommonGround=true
			ShowGammaComments=false
			Renormalize=true
			RenormImpedance=50
			FittingError=0.5
			MaxPoles=10000
			PassivityType='IteratedFittingOfPV'
			ColumnFittingType='Matrix'
			SSFittingType='FastFit'
			RelativeErrorToleranc=false
			EnsureAccurateZfit=true
			TouchstoneFormat='MA'
			TouchstoneUnits='GHz'
			TouchStonePrecision=15
			ExportAfterSolve=false
			ExportDir=''
		$end 'AdvancedSettings'
		$begin 'CoSimOptions'
			Override=false
			Setup=''
			OverrideSweep=false
			Sweep=''
			FrequencySweepType=0
			Interpolate=false
			YMatrix=true
			AutoAlignPorts=false
			Simulator=1
			InterpAlg='auto'
			Renormalize=false
			RenormImpedance=50
		$end 'CoSimOptions'
		$begin 'TemperatureData'
			IncludeTempDependence=false
			EnableFeedback=false
			Temperature='22cel'
		$end 'TemperatureData'
		$begin 'UserDefinedSolutionMgr'
			NextUniqueID=1000000
			MoveBackwards=false
		$end 'UserDefinedSolutionMgr'
		$begin 'DatasetSolutionMgr'
			NextUniqueID=2000000
			MoveBackwards=false
		$end 'DatasetSolutionMgr'
		Notes=$begin_cdata$ $end_cdata$
		$begin 'AnimationSetups'
		$end 'AnimationSetups'
		CacheHeaderFile='HDR06587864416872682124.tmp'
	$end 'PlanarEMCircuit'
	$begin 'DataInstances'
		DesignEditor='TopLevel'
		Refdes('0', 'U1')
		$begin 'CompInstances'
			$begin 'Compinst'
				ID='0'
				Status='Status'
				CompName='main'
				GatesInUse()
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '0')
				$end 'Properties'
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'OHD', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'OHD', '', 'DefaultNetlist', 0)
				$end 'Parameters'
			$end 'Compinst'
		$end 'CompInstances'
		$begin 'Instance'
			DesignEditor='main'
			ID='0'
			$begin 'PlanarEMItem'
				Editor3D=true
				$begin 'PostProcessing'
					$begin 'Fields'
						$begin 'Items'
						$end 'Items'
					$end 'Fields'
					DesignInstanceID=1
					$begin 'WindowPosition'
						$begin 'EditorWindow'
							Circuit(Layout(View(WindowPos(3, -1, -1, -8, -31, 0, 0, 136, 50), Extent(-0.880303025245667, -1, 0.880303025245667, 1, 13233.0194641431, 13227.407029494, -0.0304119139909744, 0.0617876723408699, 0.142900109291077, 0.079305037856102, 1), ViewingXfm(-0.843162536621094, 0.385907143354416, -0.47620815038681, 0.205886602401733, 313.394195556641, 321.303497314453, 8.60090065002441, 0, 0, 0, 0, 8.60090065002441, 0, 0, 0, 0, 8.60090065002441, 0, -0.581592679023743, -0.325543016195297, -317.356353759766, 1))), Layout())
						$end 'EditorWindow'
					$end 'WindowPosition'
					$begin 'ReportSetup'
						$begin 'ReportManager'
							$begin 'Reports'
							$end 'Reports'
							NextUniqueID=0
							MoveBackwards=false
							$begin 'NextVersID'
								NextUniqueID=0
								MoveBackwards=false
							$end 'NextVersID'
						$end 'ReportManager'
						$begin 'Reports'
						$end 'Reports'
						$begin 'ReportsWindowInfoList'
						$end 'ReportsWindowInfoList'
					$end 'ReportSetup'
				$end 'PostProcessing'
				$begin 'Properties'
				$end 'Properties'
				$begin 'UserDefinedDocument'
					$begin 'Data'
					$end 'Data'
				$end 'UserDefinedDocument'
			$end 'PlanarEMItem'
			$begin 'TopLayout'
				DefaultUnits='mm'
				DefaultAngleUnits='deg'
				MajorSize='10mm'
				MinorSize='1mm'
				PixelSnapTolerance=20
				SnapAcrossHierarchy=true
				SnapTargetVertex_on=true
				SnapTargetEdgeCenter_on=true
				SnapTargetObjCenter_on=true
				SnapTargetEdge_on=false
				SnapTargetElecConnection_on=true
				SnapTargetIntersection_on=false
				SnapTargetGrid_on=true
				SnapSourceVertex_on=true
				SnapSourceEdgeCenter_on=true
				SnapSourceObjCenter_on=true
				SnapSourceEdge_on=false
				SnapSourceElecConnection_on=true
				ConstrainToGrid=false
				DirectionConstraint=0
				defaultholesize='25mil'
				anglesnap='5deg'
				$begin 'TextStyles'
					TextStyle(N='<DefaultAnnotation>', F='Arial', Hght=12, Scale=false)
					TextStyle(N='<DefaultPlotter>', Plot=true, F='RomanSimplex', Hght=5, HghtUnt='mm')
					TextStyle(N='<DefaultMeasure>', Plot=true, F='RomanSimplex', Hght=1, HghtUnt='mm')
				$end 'TextStyles'
				$begin 'TraceStyles'
					TraceStyle(name='Half Grid', size='0.5mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='1 Grid', size='1mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='2 Grids', size='2mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='5 Grids', size='5mm', bendStyle=0, capStyle=0, capStyle=0)
				$end 'TraceStyles'
				'current via style'='PlanarEMVia'
				'current pin style'=''
				MajorColor=16772075
				MinorColor=16774645
				ShowGrid=true
				PageExtent(-0.1, -0.1, 0.1, 0.1)
				'background color'=16777215
				DefaultToSketchMode=true
				fillMode=false
				DocVisibilityFlag=962
				FastViewTransforms=true
				StartingHierarchyLevel=0
				EndingHierarchyLevel=-1
				SingleLevelView=false
				'show connection points'=false
				'draw rats'=false
				'display vertex labels'=false
				ColorByNet=false
				'display package graphics'=false
				'rectangle description'=0
				snaptoport=true
				autoplacecomp=false
				'sym footprint scaling'=4.1163018385
				AutoScale=true
				'measure display digits'=3
				'display measure units'=false
				SuppressPads=true
				AntiPadsOption=0
				TextIsVisible=true
				'primary selection color'=255
				'secondary selection color'=3289780
				'preview selection'=false
				AllowDragOnFirstClick=false
				PinConnectivityPopup=false
				CreatePortsOnComp=false
				OptionUseNamingConvention_PadPort=false
				OptionNamingConvention_PadPort='$REFDES_$PINNAME_$NETNAME'
				useFixedDrawingResolution=false
				DrawingResolution='0.002mm'
				$begin 'ViewConfigs'
					ViewConfigsCurrent=''
				$end 'ViewConfigs'
				currentTextStyle=0
				currentTraceStyle=0
				prevBounds(-0.880303025245667, -1, 0.880303025245667, 1)
				prevMapFactor(13233.0194641431, 13227.407029494)
				prevOrigin(-0.0304119139909744, 0.0617876723408699)
				prevViewExtent(0.142900109291077, 0.079305037856102)
				prevZoomScale=1
				$begin 'Animation'
					LabelColor(R=230, G=230, B=230)
					FontName='Arial'
					FontHeight=24
					FontWeight=400
				$end 'Animation'
			$end 'TopLayout'
		$end 'Instance'
		$begin 'SODInfo'
			$begin 'CAPC0603X33X15LL03T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'COIL-1008CS_V'
			$begin 'MURA-BLM15-CHIP-2_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'WE-Coil-PD4-S'
			$begin 'main'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'main'
		$end 'SODInfo'
	$end 'DataInstances'
	$begin 'WBSystemIDToDesignInstanceIDMap'
	$end 'WBSystemIDToDesignInstanceIDMap'
	$begin 'WBSysIDSysDetails'
	$end 'WBSysIDSysDetails'
	$begin 'WBConnIDConnDetails'
	$end 'WBConnIDConnDetails'
	$begin 'WBMaterialGuidDetails'
		WBMaterialGuidMap()
	$end 'WBMaterialGuidDetails'
	$begin 'MinervaProjectSettingsBlk'
		MinervaRemoteFilePath=''
		FolderContainerString=''
	$end 'MinervaProjectSettingsBlk'
$end 'AnsoftProject'
$begin 'AllReferencedFilesForProject'
$end 'AllReferencedFilesForProject'
$begin 'ProjectPreview'
	IsEncrypted=false
	Thumbnail64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCABgAGADASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+5jTYZ5bXS7ldY1OONrPTpAqxaeTGq20B2J51t\
JIQoGF3TlsAfOD0Zc288bWETavqTNPqAVCYtNwhj03U5C48uzRS21So8yOVcSHaEfa4NM1G2jsdMia3\
uQyWOnoUh0/VZ7UlbaEELdRwurxE9XWUrySGA6NutStnk05hBdkRagXZpNN1WKVQdM1OPFvE1upuGLO\
NyqkjKoL4VVZh9vy1/bVF7H3fft+7h0UuXXl1u9+/S5y9Frrp38i89ncssQGtamdiFTmLScAmSR8LnT\
Txhx0CjJPy5yzVrKGeaO8kTWNTRZLzU4wBFp53NHq04Z3862kYFjEzHLuu4/IiLtEdhtVtcJ+51AZUn\
K6RrDFvncZcfYzsbjGMLwoOOcmpYajbRw3Sm3uVP27VHxBp+qzxoJNWuXUxSRwuHl2uA6bmZCzqyqyE\
Jmo4j2cv3GvNG37qH96+nL3t6bbtD0utf60Pxv8A+Cw9tOniT/gj4janfzE/8FoP2XAolj08LC0vwb/\
aWCzxeVZKDMPLOAylf74f5Qnyx4O+N3wr+Hf7bfinUv2Z/jv4hl+PFn+314f/AGYP+CgXwJ1Twr4qn8\
GT6P8AtJfGP47eJPgL48t9Y1zR7HSn8a2nw08Fao1lN4bvdRjtXMEV+ulNca7YeJPcP+C6HxB0PwFov\
/BK/wAb6vr3h/wfp3hT/gr3+zjrlx4n8ff2lofhDSGsfgh+049tdeJL6WONodJW8a38wQ/6RIsjpAHl\
2qP52NO/Zz0W0/a8/aH/AGqJv+Cpdv4C8UfGD9tX/hp//hHvhHa/A3x94Ha5+GfxS+IfiP4Da5pmtfF\
H9tvw3LqdxpPgzx7qmn2WleJvCN9othaak9lfaJqMSmJcuEOMY+H3iDmvEmZUZY7JcbkVbK8dlkMMq0\
syw+Mqyn7CVN0alGMaVehQxdOpVUXRxOGoV6U6VelSqw/a/o9VczwHGvFWJdD2/CecZZhstzijVp1K2\
GxmDq0c9ksLWo08PinV5ca8Bi6Mo0ZTwmLw+ExkJ4erRo14f0E/Dn/go94J/ZC+HHx58Ja18EP2uvjN\
F8J/it/wUS/aY+NPiv4A/Dz4Y+J/B3we+Dmt/wDBVL9tLwNpfifxzqfjf4heH5ri+n1H4eePtQbTtHt\
tYvotH8E6zrUlnBpelXt1afjL/wAHenwr8K+E/E/7GvxZ0DTLaLxj8XrX4t/D74mam+swWM3im0+Hlx\
8LtT+G17d+E4p/suq32mp4r8VWs2sDSp5ltL/T9P1C5ItPDy2/yn+39+0F+zz8YNb+FuueFPBXwq8d/\
Eb9lv48ftx/tDeINP8AH/jz9lDUPAvxq8D/ABe/4KT6B+1D8LPhp480dvjX/b3x3+Flj8LdT/aF07xD\
4D0hJNVg8YXemva6fd+H/FOg674i/KD/AIKI/tt/Fv8AbA8TNfeN/i34g+NFr8H/ABT8XfEPh6T4l/D\
PxRqGneIX8ZA+EWj+E3hp/Eup2Pge11GO9tL99O0xtI0+xtNDtL6CRpdB02A9/idX4Z4v438YXxDnkM\
myrE5nVzHJqlTBONTGwxmYVquHxFCNVUsTKnBSpVKqo0alZ0ZSb9lTqudH9i8A/DeWVZHgvEfLeL6XD\
2ecMUauAzbJ3WdTH5hDGzo4CvhqNKMqGEpww2DxUMxqvG4uCq05UPq+GxFTDzqVPyE+IHiv4jfEjxVq\
Pxf+LOq2vxAl/wCFm6/H4tHi/wAeWt38QPHOv+I/EmpfEbxZfeLbCTxOvjDVIdYv9V1aTUPErqYpLrU\
WiGpLqDBW/S39nH/gnX/wUo/bA+BEP7UPwx+Bnibxh+zv8Dx4j+J0HxD+J954TttE8bXXgjUPE3/CYR\
HVfi74l0V/i34WtrXwbqNjqsnh2z160tDbtorwSajFc2KeV/AHxZ8BNJ+BWh+B/iR4D8Q6Z4iF34gfx\
NeaD8P/ABvoOu61/aFr4v8AD62+r+NPCHjXSr/xHpT+DvHGu2D2tzI1qbPWrizeAxErX6j+BP8Agrd8\
Tfhn4J8JfDnwF+0d+1P4S8D+A/DukeEPB3hfQ7/412mjeHPCvh3T7fSPD+haVaJ8VsWun2mlWdrBDGO\
ESFVyQMn7Xh7wByDinI+Esbi8+wdDB4enSxlLGYTM8ko4xPEq+Lw1PCY/M+TBy96dsbOm8TOrOUq2Dp\
zvzfu3hn4H5hN1uJc7+kzwflOR+IeX5RWzXIMyxucLHSpUo4XE0cozT6thMKqcso9nRw2GpSrYvBxnh\
r1MD7KKw7/Aj41eOfibrfx/sfGfxMsdT+HHjHw3qXhHw0+oeC7zUtIWOL4UajP8Nk8U+Bdc1C9k8vVb\
SbwhcJFqFtPLbjWNLu54Ps//AB6wf0vf8E//AIp+Hv2Rf2af2VLe8+NOkeL/ANnjxH+21qvxv8YaLp/\
w40nwf8RPhn478Tfsf/G/9n3w74u0bRIPF+qXXxF+H2seBbfSNR8SX9o13d6VrXh+9sJNB02a40O88e\
/lj4TT9mv4y2er+PviVp91DrHgzxb8R76DxJq2g/Frw6tr4e1b43fEnxVob6dJ4N8ewxtdwav4ihDny\
/tUF5qtvZiWWYRKPsr9nv8AZ0v/AIheEtOthYeKNX8EfCXwRq2peCfhlqRfw74r0zRfDAaz8deOfF+i\
2Guvc+LPGtnBca/LNZae90mheGNM1TW7uztoYNbuNK/0C+if9FLCcN8ZrjPMuHauE+j9ieGM4wuBzrE\
4nJ6+JxGYYytg8LhMNThh8dXVPFyy/G4+dLE0aVPDUIYKlPETpuvSwOZVlv0QuEfEPhLjngytxpwz4h\
f8RawOBrZVWw2a1I5jwtlco0cJmWL4g58DQwmApezeKy/L8Rh6OOx1bO6GFhQhUwNTO/Z/6iWkmb+z9\
JLS7p/7P07Evno+G+ywbG+0CQgYG3nd8uOSMU28MnnaWFfbGdSbzU81U8z/AIlOrbP3RYGXDc8A7epx\
VHTLZpLHTJo7/UILdrHT3Fmh010RPs0JaFJpdMZ9vBALFmAPJJGabdWsiSacj6jqEssuoFYZmGmKbUr\
pmpu7oiaYFkZkUp84ZQrkgbtrL/l86cfb1f3kb+/paWmkr9Le7vo3a3u8zsn/AJc30Xy/Q323YTc2Rt\
Owbw21d75XAPyfPuODj727GCCaWnGbyLrzJd7nUNX81vPSTzF/tm72rvWQibB8vgE42ZwNpxE1lcEIF\
1fUlKqQ52aQd7b3YPg6V8vyFVwP7mepNVLC2aSG6eK/1C3Rr7VEjiQ6bIInj1a5WSYvLphMjOUlLAkK\
GnO0KqqozVOPsp/vItc0dbS0+L+7fXfRPbWzsm+q/rsfj3/wWL3f8JN/wR5y3yf8Po/2WNq7wcN/wpz\
9pjc2zOVyNnOBnbgE7Tj9pAZPMQh/3n7rY/mqNuFXyv3u7Ee1do5I2bcHGOPxO/4LD20qeJv+CPqtqF\
9M7f8ABZ/9ltd8i6cNm/4OftLiOSNYdPQeahVyN25D5vzIcCv2fFnN5iMdU1Ixr5W+LbpP7zYqiX5/7\
Jyu9gx4+7vwOleDhoR/1gzde1j/ALrguktf3uO/u/nb5HjUP+SizTT/AJgsB/6fzI/zzf2tvhl+074n\
+O3iTwl8eP2ZfDH7QP7POmf8FBv+C3f7Tf7OS/Hf4uDxR4C8e/Czw/44trf4x+B9E8C+Dfilo3iP4Qa\
B8Pr74XeO/F1vbjVtLXxNq/jOdLDSJ3+0nVvN/DP7HM/x/wDip8Vv2Wfgr/wSA/YM/wCF/fDqz8e6Z4\
z03SfHnxj0PV/AV14R1Rvh94r1vSNf+If7WF94Z1zV9F8batpQtImh1iyvJYkuJLS805J4pP2R/aY/4\
JZ/Huf4V/tdaF8FPFHxD1f4o+Of+Chn7YP7aXw01my/Zq1DQfEunWf7R8GpfDL4p/AnQ/j3afF5lufh\
x4m+HkOdRgfw5Z6R4imjsdL1iGGwjGsW/wCCXwP/AOCgf7d37Hn7Yfj39oi68A6ZqHxu1/xL8SdE+O3\
hzx/4Yt/D6eKdX8W+Kpdb+I+ja14agtdPuvAOtr4202O9SK0hsJNNvtHjtJ7R7H7Xplx+A+LGU47h3i\
3JqnELxeS5Tm8uWvUisqVKWHgpxqTwmJjGc6lam5Ubwr1KuJo0LJc0Pqrf+8v0VMTl3En0eM3y7g3hP\
LeLfEngfAY/+zsPWln2PrVM3qZh9dy9ZphcDXp0lluJw1atSeJlhsPhsZmMeZYmEJY7B4GL9pX/AIIV\
/tvfCjwD8Rfj58Rv2CPhn4I+H/w28GaHcavpfwi8VfDjxhHpemaBYaXoniD4g61pWjfEDWtW1FWliu/\
EPiOe0tk02zW91S9t08O+G9Ohs7HzH4TfF79mH4G6h8Pbv4if8EvP2BPi14m+Gi/Dnxldahb618XNVu\
Pi9bwWPh/xnZfb73Sfjrrng3w74w1PTpUi1jTNT8Iy6XomrXM2l614SiNrqXh2y/qG+CH/AAVw/wCCw\
P7SPglfiV8Dv+Cf3w7+I/guTVNR0KfU/DvjC0uBpOu6ckMl5oesWcvjJLnR9Yht73T7gW93HFLJa6ha\
XiLJaXdvNN4rBpH7cskJ8r/g3e/YdYLcXatIPgZ8ESS6XDxSRn7QzkbJo5RwQmSRGqxBEX+jOFPB7C4\
3K8pzDEwznG0MPLC4rLsZlWdcA0f3cYU5UZKu4TqTvye09o6s51ZVOdyjUpxm/wAOfi9xflmY8SZJ4o\
eEnBmTZ3yYrAY7B4HN6mVVnUrKrCs8xoYvPp4uOMwzqctKM6qpU4wp01haS+s/XP5eYfhR+xWv7Cv7K\
Hj/AOH/AIy0lP20NL8Q/Hnw1+1b8LNX8M+P7y8uryy/aD+J918J/iF4X8Waj4Ek0CPUrbwBFomnavDY\
+JfKkit9Dms9Mj1KLxBc3Pdfs7/tbD4faE1/4s8S63ofivwR4i8ZeKvB/i7w9cagniy4uvDfjzUruwl\
sJ9MlW7t/FVrqTaa1pfxvHumeBpp4bsJNdftH+yn+xb+1b4T/AOCc3gj9lfxF/wAEBvBn7RniO38Qft\
C+BfEH7Tmi/tc/sd/syfHsa1pP7QnxS1LTNa0XVvFfgHWPEXhvVtFuLddMtbfUdU1bTbqx8Ix2l5Z3u\
iXv9mv+YXxE/wCCJH7X/wCzb+z3q37RHx4vPgF4P8TeMfE/xG02w+Btx8YbLxD8d9J0rwx4w1bRtStN\
G8PaXpU+jeMbaHxWLK6ni8Ja1rc8MXjHTL7UILdI786Z/ol4P+KvEvC/h/mUeGszo4ri3A4ClhsLl+Z\
Zjhc6ea4uvg81xGFoV8JhcbDGYijhZ4atCq6VOjPD0qWGw9WrCtjoe2+P+jF49YXh/j3gPgPw9oUamf\
59hcZgq9GtXwuYYPNsJjY4HHxq0q2XReExroRaweFoSnQq4WnKlTrVJyp4yhP/AE6NNvhDa6Xby294L\
pLPToykejXzwGT7NAECmCyMMiHK8glGBzkgk0y5v0kawkjgvjDBqAe4Z9H1BXUPpupxRiHzbIOzGRxl\
YsttBZhsViLmjiP+y9JCu5i/s7T/AJzGqybfssO4+WJSMjnA3c46jPCXoT7RpBZmDjUn2KEBVs6Rq27\
e5cFMDpgNnpx1r+AW6Xt6q5Hf3+um0r2jy3Xldvl3d7H+aetlr2/QV9UgCxFodRAZC0ZGi6qCyeZIpL\
FbDJPmK4+bnCgfdAqtZXwhjvI5re8WRLzU5JhFo18yJHLq07xlTb2RVH/ewhguHUsyuAQ4rZO3C4JJx\
8wIAAbceFIY7ht2nPHJIxxk5+mCMW9xsd2UajrGwtGqszf2xeZDqJTsGC+CC2do4GTjNOj7Kf7uVuaP\
VX+115NOt9NXZ7JpvW6/rsfjH/wWHvopfEn/AAR8ZYrxY0/4LQfsuSbpNLv4Wbyvg3+0sZUQy2itM+H\
j2xruY7jsUndX7QDUo/OiQW+oea3keWn9iantbekZh3KbDacqyE7uuTv5zX41f8Fi9v8Awk//AAR65O\
7/AIfRfsr5GBtC/wDCnP2mtpDbuSTuyMDGByc8ftFhNyjc2w7dzbBuGQN+1N+Gwd2ORnAJ25wPBwzpf\
6wZv7krfVcF9pf8/cd/c1+7U8ahf/WLNP8AsCwH/p/MjC06/SO2uA8F9kXOoTPs0fUHCwTarNJCwaOy\
IWUrLDvAPmBmZZAG3ivw+/4K6f8ABKfw/wDtl6Kfjn8DNGg8OftU+HtNUXUEmnS6Hovx58OaPp11bWP\
hrxPeXNpFDZfEW1gtILTQddndEe3hi0TXpk0aHTdU8M/uZpQT7LNhm/5CGrlcoBlzrF5vU/P8qjL4PJ\
O0ZUZO0vgn2nRvmbd/aEpxsGN/9laqNud/3fL5zjO75duPmrTifhnIeLsvzDI89wLxWCxPtHdSSnSqR\
jPkrUZcjdOrB3cJ6qzcJxnTlOEv2jwc8YuP/Afj3I/Enw2zqWTcRZNJJp808LjcNKUJV8Bj6ClBYnA4\
lQiq1GUoyUo069CpRxNGhXp/xA/sV/s0/tvfADw34m13QvCPjLwFrPxJ/sz/AISLwL43+Ev/AAWu+Hf\
inw4fBN/4ts9N/tS5/Ym+F+jaJ4h+1WusXF5D9s1fX/sVtdxLbf2Vdzaray/Ztq//AAUHjtyfLnCtd3\
5B+y/8HQABZruSRsNbRlSf3inB+cbgZf3pcV/WHhNzDc2wb9rbBuOAdm5N+FydueTjJI3Ywc3SwgtJN\
rMT/aWs7gyBQP8AibXh4Ic5+cuOg4UHqSF/LMr8GsLlOWUMvweeSWGwvLFc2G5pNy9pKUpS+sJXlJyk\
0kopytFRilFf2Vxl+0Mz7jvijN+LM/8ADejPNc5qKdT2WaOnShGEKVGjSpwWWt+zo0aVOjBzlOrKMFK\
tUq1XOpL+PD4Jn9v9/Cd2tpHOyj41ftCPgW3/AAc1OftUnxx+Kq3WBpieWSbqWYYX/TvmxqAF19tx+H\
WnfDD4h/EX9kf9k6SS18N+CtC0+P8Aa2uvDPxJ8RQftJ2ml+MrbSv2g/jBqlz8NLO/bT9R8Pz39p4vM\
i2UfgSxs/D9tefFC2l8WanHqMmtXGl/6Iel/DD43eCpp9J8I/Fr4VweGtT+JfxL8baVbeJPgR4u17XN\
Nk+JPi7xx8RNQ03UNX0z9onS7fVktLvxRqFtDNHY2RljtoXeJGL5+PP2n/2SvjD+1V+y54/8Aa/8QfA\
GpXug+MPip498AWfgj4D64fGjfE3wx4s+Idvp0egL4v8A2wdB0DUZNTfUtb06Kx17UdP01bfxEI7nWd\
NuIYvEFn+veE/BPAGDzXN8H4vYTMs48OuNcFRyjNoZbOGExeEp1M1wWb0sdQqwr15V/qeLyahOWFeFl\
7ek58qjVhSjU+M+jx+0Sx3h9xL4XcPcU+B+cZLl2EwNPBY/MsHneTYmWEp08BRyqtjKODqYihTxUKE8\
ZHEuGIk06VKSjhatWcHR/UnTBfNY6ZLBLp8Vr9h09ktXsbuZxELaHMb3I1VS7EA5YKvJyFHApt0uoLJ\
pyS3GnyTSagRbTLYXUYt3XTNTaRni/tUidWhDrjKlWYNuIBVpdN1K1htdLt7jVLNL9LPTonSXUbYTpO\
LaAIrOZ/kcHaOSCpGDjFMudTsZGsJIdTsWt4NQD3hTULbYiPpupxQvMom5Xz3RQSCAzgcEivX/AH3tq\
j9l7vv2fItdJcvvct5Xdlr8ezvc/hjSy17foW2j1YhAt5pqlVIc/wBl3Z3tvdg+DrPy/IVXA/uZ6k1U\
sBfPDdNBLp8Mb32qLHG9jdzGKVdWufOkEn9qrvVnSYqpHyLMBuYruNx9Y0sLEX1bTtrITFnULUjy/Mk\
U7R53yjzVk445ye+TWstStYY7xLrVLNJlvNTlnEuo2xdoJtWneBmJn/eIyy27L1BDKw4GRmlX9nK9Kz\
5o2XIlf4r6cutnZX6X5VpJj0urP+tD8a/+Cw6agPE3/BH1Zbixd/8Ah8/+y3seOxuIsSN8HP2lxCZFf\
U3DxKVkJUbGbzPvrt5/Z8JqfmIxudNMa+Vvi/s28/ebFUS/P/bOV3sGPH3d+B0r8Yf+Cw+o2M3iT/gj\
40WoWcsUf/BaD9lyVvLvLeRYli+Df7SxnmdUlPloFeHc5AHIyeOPSLr9mf4E/Gj9uz9trTfHvh/4j6N\
pfj39n/8AZBl8Zx6D+0T8T/h14W+NjeIoP2lPh/quq6toPwh+NNnD4g8KDwN4N8LeGG0zxDZWnlT+E9\
Wnt9JFprEura58TjcfmeC4jrUsBl1LGYnMYYSjy1ZyoQgo0s3xPO5U8JiXvh1CzhFLnclNyjGnP6Tw9\
4X4d4iz/wAQ8bxRxDjOHsq4T4fyrMZTwOX4XM8TXdXiGllPsIYbF5vk0Pdhmk8VzwxFWbeGVJ0I0qlX\
FYb9RtNXUDbT+Xcaeim71JFD2F1IVnTVbgXE4I1Vcq8iTFUI+QTBdzFNzF6uoCbSVa408yG7kSORbC6\
UJP8AYNTkM7odVPmL9mEkewFfmYSbvlKt/LX8L/jx4t0L9u3RPil4F8PeNP2XLDxhrXhH9jexvv8Ago\
D4H/a1+MPxpuPBH7Seman8TfgdqkuieNv2tr2XXdHuf2hv2cPi54eibTLrwzovh+28Z2Wq6hceJri+1\
Z/Cf9Fn7PPxZ1H4x/s9fs2/F7xTP4dsPEfxN+D3ww+Jfimw0G4e10LTNV8b/Dq017WLTSrTUNUuriz0\
aLXtXlit4ri5uJkTyxLPNJmVteFeNKfE+MzLDwwKw1bC1MVGLi1Up1qdHkg6sHOjQrqMpVYxSq4eEZy\
U1GU5QqKP7L43fR4zfwawHDWa1s6/tjL89weW16sKuFWExeAxWY0sXXhgsRHD4rMsuq1IUsFUqSeEzT\
EVIU50KmIoYaGJwrr+8FNT8x2FzpojbzdkX9m3n7verCL5/wC2ctsYqefvbMHrWfYLqD2rCC40+HGoa\
qHL2F1MXcahcJKw/wCJqoRWuEndRglVnCFm2Bm0jq2n+dKh1bT/AD18/wA0/wBo2u47EkNxufz/AJvk\
EmeTu5HOaz7HU7GG0IudTsUDahqrxLJqFt9yW+lnidVM3Ctay2pU4wUK44HH2UVX9lL9zreFl7Narln\
rbl19Wfzrpdf12C6F8t5pJkl0+QG+CxqtjdxhZU0y+aaRz/apMivElwu0FdrXAYMQm1vnjxd8XdL/AG\
eP2bfjx8fvHTzXvgr4H6J+0v8AGDxda+HtEjuvEE3hj4ZeJPiL428RQ6Haan4ps7W81iTR9Dvo7WK5u\
7WB5pUE1zCm6Vfoq51K1kvdJ8nVLNnjvI5ZGTUbb93BJpl3Fas7ifCJ509mq5OFZkHBHHzr4v8Ahp4C\
/aJ/Zq+Pn7P/AI31+7sfA/xy0H9pj4PeNrzwzrel6b4jtPCPxP8AEvxE8E6/daDfX9tdQWetR6Zrs72\
ks1rdRRXCRSSW8yKyN22xDyXE8tO0va4bVU4yafLjbWUklfZpNpSvq9Wzy/3f+tOTe1SdL6rjeZSclF\
x+sZZfmcE5pWvdwTkl8KbsfSejiP8AsvSQruYv7O0/5zGqybfssO4+WJSMjnA3c46jPCXoT7RpBZmDj\
Un2KEBVs6Rq27e5cFMDpgNnpx1qvpserG10spLZxKbPTjHay6TI04X7NBsjbZfRo7lcciEBi2Shzgsu\
Y9WDWAaexkJ1ABJk0qYJbv8A2bqZ3TF9QdirIJFAV4juYEswUo3C4x9vVft43fP/ADdVK+vJZ/Lf7Op\
6nRadjcO3C4JJx8wIAAbceFIY7ht2nPHJIxxk5+mCMW9xsd2UajrGwtGqszf2xeZDqJTsGC+CC2do4G\
TjxjxT4H+P2r/Gb4X+MfD3x38O+Efgt4S0fxND49+C8PwW0/WNX+Leta1p2r2Oj6lqXxW1TxubnwnpW\
j6g+h3llaaTpcM089hfw6nf31pe2tvpXr1lHqxjvNstnAPtmpho5dJkLxMNWnEkjeXfRhEaQHaFRCBM\
qs7/ADGTjw9SVWOMhUpyw0aFaMIym4NVoqCkqtNU5VJKm3OVO1WNKqp053pcjpVKnp5hgcLg6OU1cNn\
OGzapmOG9vWp4eGMjPAVXiK9H6li3isLhqc8SqdGniubA1Mbg/YYqhFYv61HFYbD/AIx/8Fp9b0Pwxe\
/8EkfEviTWNM8P+H/D/wDwWO/Zn1vxBr2uX1ppOh6Hoek/BL9p+/1PWNX1a/njg07TLayguZrmed44Y\
IbdpZJAgYr65408U/8ABML47/EfX9X0H9vbwr4f+NvxssfBvwo03XfgR/wUj8ReDPGF7qoa98MfC/Qf\
Anw98GfHoaDqeu2nifxhqU2haQdAvbO913xVeTzaXe3ms6it78ff8HEGmeI9U+Cf/BP3S9OtLjXtV1P\
/AIKZfDPT9G0nw94c1TVNZ1bV739l/wDa0t9P0zStJ02e5utb1GW5kjihs7aOS4uJbqOKBPMcLJ+MP7\
PHwU+IUU//AASl8A6T/wAEs/2pvg38dPg1+2b8EPFn7SP7RE37Nvxw8N+APFHgnTfjdo91out+K5dVt\
L9vFE0ejaxc6hqOra1Jpdh4Li0fUI9HjGga5cw6X+Q8V5xUw3GWJymeT4fNsHVwOXVk69LEVOarPG4v\
COnQdPD1Y068KNapUVSfLaN03GLcj9x+jpwi82zLxK4lwPiDmHA+bZPgMqw7ll+Py/BRWElQ4mzeVbM\
o4zH4SpjMveNyXA0fqdGFSNSvKEpc9WNCnL9pPiT/AME+vjX4a+PPwm1vRfF/7a/7TXw1+EHjj9ln4x\
6L4j8U+IP2RPiV4n8UeK/2fvjX+1d4t134a+N/E3xT+KHwz8S2xgsvjBYy6BraXOu28EHjXWbG/s9Rh\
sPDlr4e/YL9lrwP4l+GX7L37J3w38b6c+ieNfh98Dfg94I8XaKbrTdSGkeKvCfwksNA1/SjqWkX9xaX\
62+pWF3H9otZ57eVot0EksTLK3u2nR6sba42T2KL9p1AMH0qZyrDVZg85K6gu2J5ASmAGAmVWkkO5pP\
Af2qfHfxa+GHwgfxj8LtKtfEHjC08a/C7R4o4Pg/8Q/jCdH8MeLPib4a8J/ELxqfhd8MPENt4h8eR6F\
8Pdb8V6t9g0q7gupX0EEzGBJIH+2wHCmR8IYvOs9weIrzjGji5zoyqOqo0+X20oUuempLl9kowjKta1\
7tt8xtxV41eInj1guB/DPPcPlFKtLH5Zh8PjKOEngqtbFOM8vpVsdKhOdCXtHjJ1cTUpYJVHJJwShFU\
n9N4Tcw3NsG/a2wbjgHZuTfhcnbnk4ySN2MHN0sILSTazE/2lrO4MgUD/ibXh4Ic5+cuOg4UHqSF/OL\
4cftFftKeIfjT8IvBsupJ498J+MfFfizR/iNLL/wTK/bf/Zej8B+GNM+EnxL8W6d4wb4nfHD4mX/h6E\
Hx/wCGvBWi/wBny2v2i6/4TDNo8UsIYfE2rfFbVLXxzrVz4T/aZ+L2q/t/wf8ABR/XfAXh/wDZU174g\
/Erw74L1b4NL8YLnw9p3g3Wf2e9N8L6pougfszT/sVCPx9c/E2Hwdqd5a6pcN4gj8XXmsRjS5uetxvl\
9HBKuqfuyrODU6+H950qUKkoYeVCpiIYrE1Y4iCw+FpT560oVo3g6dpaZP8ARt4ozLOMRk1bM1DExwG\
HxlN0ctzdqjHF4vG4Onic3p4/BZZiclybDVcvrSzTOsZQ+q4CjWwVbkr08UpU/wB970R/a9G3O4X+0W\
5Ealtx0jU/MG0yjgAvg5+baMhdx28l8Ntv/CO6lkkH/hPPiptAAILf8LR8X8MSw2jbuOeeQBjnI6S5j\
1YXuk7pbORjeRiNU0mQbW/sy7IkdGvnEiPGGVQApLXCFnkG5JfHvBPjvw1oel65pes/ELwBpOpW3jr4\
ni50/U77TrG+tPO+Jvii5ia4tbzxEskAeCWJkyELJOhDFGw36fh8JWxWVYinh08RONXDNqEKk3a2NTd\
o020rtK7W/qr/AMnZjjsFgM+yqtjsXSwVKWEx0VKrUhTi5OtlrUVKcknJpNpJ3aTa2PXtMv8ATYLHTL\
OXU9PSdLHT4XR7lY3SQ20IKvDIBIrAnBXZuyOAeMtutR0yWTTpk1PT2S11AvMVuo3CJJpmpwq7uhKxL\
5rouXZQWcKuWIFXtHdTpekuIkVf7O08+UDJ5eBaw5XLSFsHBz82eeCOMJesBcaQpRWLak+HJfcmNI1Y\
naFcA5HB3A+2DzXmt0/b1vcnzfvL+9HtLm05NLrzdulz6Pou2n6A2r6QoQnVdNw6lx/ptuOA7p1ZwG5\
Q8jI7ZyCBUsL/AE23huopdT09HivtUmIe5WMmOfVrl4mCShWVWSeNlZgqsrAqTuXduEghQFAwMEjdlj\
uJ3NknnBA4wMKOM5Jz9MdWt7giJEDajrACqZCsZGsXhLJvkJJO053Fh85wBxjNOl7KfuTtzRv70e07f\
Y7X6fc1q+q/rseL/HH4J/s7ftIeGvD/AIM/aC+FHwV+PPgbSfFkfiu08H/GTwF4K+KXhTTfEWn+Htf0\
ax8SW2heNdHv7Ky1qGy8R6law3ixpPHFq9xAsirdFJfnMf8ABL7/AIJUGRIv+Hef/BPfdJ5WD/wyT+z\
p/wAtVVl+UfD3c3Dj7qnP8O4EE/ed8wFxo67FJOpTfOS+4Z0jUiMAPjgKwHH/AC0OcnaV0tw3K2xcDb\
lMvtbaADuO/I3EEnBH3jtwMATUjh3Gk3Rk24v7Uf55W+xrt5dOwJvXX+tD87LD/gl9/wAErhBN5/8Aw\
Tz/AOCfe9Lm/lHm/sk/s7h/s8mpTfZQPM+HuRF9nlh2E4QoF2MVKbi7/wCCX3/BK7zdMeL/AIJ5/wDB\
Pvy/tMktx5f7JP7O+37P9j1CFRMV+Hu3yvtXkYLHZv2Lu8zC1+gOlMPss3yKM6hq6jl/lK6xeZcZf7x\
2nOcr85wBxgvmH2nRhsXP9oSruy+c/wBlaq2/7+N235em3Hbd81aOGH+sVl7B3XtOsLaRl05NNtNdNN\
7Cu7LXt+h8GH/gl9/wSoEjxf8ADvP/AIJ77o/Nyf8Ahkn9nT/lkrM3yn4e7l4Q/eUY/i2gEijZf8Evv\
+CV0dsWuP8Agnn/AME+9732pbPN/ZJ/Z3V/JN9NLb4M3w9GYvs0sGzBI2BSv7sozfonuG5m2Lg78Jl9\
q7gQNp35O0kEZJ+6N2RkHN0tgbSQBFUjUtZyVLkt/wATa8Xnc5HVSeAOXPbaBlGGG9lJ+wdlKHWHafX\
k02/LsO7utf60PgC5/wCCXf8AwSue60xIf+Cen/BPvb9rV7jy/wBkj9nkr5E2n3Yj85Y/h2T5X2ia2w\
WG0uE2FmMe6yv/AATA/wCCU7ByP+Cef/BPfCKHP/GJf7OR4LonVfh8QvLjk4HbOSAfve9dRd6MTEjD+\
0WG0mTbldI1Ms3yyA5bac84/eHaF+XboAgBgVByMAndlTuB3LgjnAI5yMMeM4IJwwyjR/cPWPeH88v7\
nl+VtgTeuu3/AAD/2Q=='
	$begin 'DesignInfo'
		DesignName='main'
		Notes=''
		Factory='HFSS 3D Layout Design'
		IsSolved=false
		'Nominal Setups'[0:]
		'Nominal Setup Types'[0:]
		'Optimetrics Setups'[0:]
		'Optimetrics Experiment Types'[0:]
		Image64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCADIAMgDASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+7ezuL/ZceXLp8qnUJTvfVo0JceIdRaZQE0Mgr\
ExZlPBIw0igHYtlbjU90v8AyDRme3IP9sD5gNVuWL86DztQiXjj95kgphQafLcmK4JafP8AaV3nKSA/\
L4i1Ix5zpC/x5xwMngeaf3YuLJPmT5puZoCfkf7w1K4Zc/8AEsPPmliOnzEjax/cp79RxVSr+4g7TXW\
XePn5f10wvt7z/r5lOG41MSWef7NQCC0DN/bAHlEW1+GT5tBwNpZV+bJHn/MSSpGfBcah5N6EbT5H+0\
p5sDaqqiCT/hGrRREmzRC7qV8pctht0xXG4K53IpJw9rhpsiG1CYRyQogvQm3GmNkbWfGA/BOGfBaPN\
tZJyuoqWm2C8QKCjhQv/CNWC/KTpigjyy3/AC0fjJ3AfvVuHLeq/q8NIx6y/mX9br5B0Wv9aE01xqZk\
vMf2a4MF4Fb+2AfNJtrAKny6Dg7irL8uCfI+UghiRrjU90X/ACDTie4JP9sD5QdVtmD8aDxuQGXnj93\
kAJlTclknL3WWmyYboPlHBKmCyD7s6YuBtVM5CcAZZMhpBpJ8x/NNxNOR8j/eOpW7Nj/iWDnzQpPX5g\
BtU/uXyi48tL/Z4aW6y/l/rsO++r/qxlR3F/8Abb3EunmUrphaI6tGEEQ1rVmjuFf+w9zMQZHIKhFCK\
QWViq2UuNT8uL/kGqRBpAK/2wPlK3LF050HP7ofNzyM/vCw4oiluf7Rvhun2+RpTfckxv8A7Z1ls5/s\
j73mc43Z3ceXn91VxJJ9keGmwIdMAwj42pOxix/xLDwGzt5OT0ab7oupyqT/ANnhvT6y/lp+n9deok/\
Nr+vUp21xqYW3z/ZseJ4iR/bAGwDSlUv8+gnGH/dc5HGCN/zV+B3/AAcCzX7fs5fsvLMtkB/w0x8XSI\
4tRM7f8osf+CiCSOUOlRsNieaoO4gtEqMAzNIv7+28k4EG1phiaMrtRz8w01VGMaY+T5XH8Xy87SP3x\
/Az/g4JaQ/s5/svKxfZ/wANMfGA4KsF3D/glh/wUUVeTaKM+WBj94eOdrj963JjXH6tiX7CEfcWqcr7\
/wBf8A4sz/5FmYa/8uK3/ppn6jftl+GbH4g/BDVPAfi7TdN1vwn43+KX7PPhHxNpY8RX1l/bHh/xL+0\
P8F9G1nTft2k6Xb3NmLjTru7i861mhnj2b4ZI5ELV8kfD/wAdfEn/AIJ7+ONG+APxbfxR4x/You7TQr\
D4FftN+J9dh8TTfAyY33hvw/c/DL9orxXpHgewtfC3gqbxdfW6eF9Vu7SCy0u01jT9N+3XelW98nhH7\
n/aYeY/D/R97SnPx3/Zb3blcZB/ac+CGd2dPTHCx9dnReRkGX8pv2jv2zvhp/wUF/4Il+L/ANrz4L6P\
8QPD/wAMvi6ukP4a0f4maPouh+NbMeBv2v8Aw78Ndb/trTPDep6tY23meIvBmpy25g1K5D2s1vJIbaV\
3tF/T/BfGRznxCwXhfnGAhmPCPiNiMgy+vTk6qlgMVi8di8Jh83y+om44fMsIqsuVyjKni8M6+ExFOr\
QqP2f9O+A+MXEWbcH+DWf0Y5rwL4tcSYPKMVRnO1bLcbj8RleBwuf5S+ZvD5pl6rTXtOSph8XhZ1cvx\
1OpQxEVD7j/AOCnk963/BNr/goOtxJYxRN+xj+00C0OppPJKf8AhVHj8oixPo8Yk3Exk7XQgXBIONi1\
9zw3GpiSzz/ZqAQWgZv7YA8oi2vwyfNoOBtLKvzZI8/5iSVI+IP+CoUk/wDw7X/4KD/NNhv2Mv2lw/y\
PgqfhR48Lb/8AiWcDc0mcmPkn5lwVi8M8W/Er9pz9pr/goB8Sf2XPgn8f9c/Zd+CP7I3wf+D3ij47eK\
/Bnw6+GHiv45fFf4n/ALRFj8RdW+G3hz4b33xr+GXi7w34Y+GGieFPAsl1qesTeHr691DUtVvNDs4j9\
mk1fSeLOsRToeE/BjeGVSVbiPiWnCEbtyk8r4RbtdpWUVKUm3ZQg30P52yrLquZZlj4061PDUsHhIV6\
tWrJxp06dOdZK7jGcnKpUlTo0oxjJzrVacElzXX6l/aNU+y42abn/nn/AGwf+gNs6f2Fu+/+66+3+s+\
av5dP+C9X7B/jLwX8Ev2w/wBvP9nr4o/tcwfE/wCIni39nnxl8Z/AHwl+L+h6b8IvD3hL4F6Z4B8P2X\
xs174beGPhJB4l8cW/g3Q/AtprCCHxLHJoN9cXnihJ7XTtOvoD+p3/AATt+On7TmrfED9sT9jf9rTxx\
4X+NHxa/Y18c/DeOx/aF8JeGtM8Bj4wfC34++AtX+IXwyuvGfw70HQbbTvCHxH0vw/YT2OrJpSR6VKh\
tfsouHhudYv/AAD/AIOO7z4bw/8ABK34zL8VviR8Rfh7pk3xA+Eb+GY/AXhf/hMj498e2Hi/SdW8M/D\
/AMaeFbrU9Ct9X8CXj6bPdag1xrGniw/sODVLaHVb+xs9H1X8ozDLqXFmVrDYXJXmOPrRqrCUIxlLEL\
Hcs8PTp0oLnviVVlKhGKU05txSknY/V+Ac4z/wv8S8rw1PP3k2FxuIy/C5jXoTnLC4zJcVisDjm58rp\
VK+AxNCGGxkY/uqk4RpS/dVEuX+HHwt+0l8b/gPpn7Ufwu+EHx3+MWv+DviG3jnxv8AGT4p/Dqb4oeG\
NX+JHgXxNYeHPAT/ABT+OPhTUpLjxF4Q1bUrrXkklik1K+1CObxpBax2Fnq9w7ar8yfFT9vPw/J4I/Z\
F+FegeCfE/wABtS/Yk8a6r8UPAmr/AAU8JS2XxP034tyL8FfDmseMfiTqXxN8baxc2/xLsvG37O3g26\
TbaWkNhI9xpsdlBpp0vT9J5/xDe/B/4ij43eOvEvij4ZfD573w58VPiH4N0DwV8L/GPhzwt49uL7U/D\
PizQ/gAvhbwiz3PgbTJtL8beN7O0n1K9vLGwfwXaeHoPFyaLFZ64nV/s5/smfsj/txeKP2mPiZrHxP+\
MXwl8UeKI/2q/FHwg0zUPDqeAfhnpXjX4Zfsn/G79pbW1+JXxKs/A3iDQNM8ItrnguA6hpNrrEOq2fh\
TTr4/abi61Czu7L8n4C4erTzvPMHn9bM6maYL2mEpwm66hg6+AqTxGJlPDx+s1cLQw7wFRypyVPmcVO\
q1OrBw/wBAfHbxYw/CGD4Xy3gvw24Uw+UcUZdVzfHyrZfh4V8TTr0sPUwtLGY6OGyh51mtTB5xVhV9r\
GrRgqlbLsG6MMHjVV+dfh98I/hFrXwa1D4/fDP9rLx58LvHEfxf8N/CPTfhF45+HnjnXNe134aa8mn6\
18QfjF/wsrw14Pbwvomk6Vqiacsfh6O81HXtZfQNQmMenrDZR33deLviB4n+F3g2z0f4p26aP8RviL4\
Y+Gxh0fXFmstb1bwt8QfBsniHwv46sdAsNAiln0bV/BeqeH9SsLiO1hsXj8U2UiTSQywmf7b+Nf8AwT\
L+E3xf+NXhXRv2MtS8HaNpnxL+IvjxvG3hX9jn9oD4kf8ABUHxD+zr8DvEnwk+FniRLnxP8IPgJ+xj4\
a8fx/CPS/F/xQg8H33iK81DxLfNd64/hy8tdQ1DT5tS179OP2G/+DYf9or9oj9nP9lvx78bLLSv2G/i\
f4V+IPxZ8S+J5vHHh/VPiz8UfiN8EviL8A/2b7f4Hxav4I07xXpkngO60rxX4Y+Mlnf+F9YvdG1vQm8\
VXJlhWW3W1P6r9InwrxGO45xlDHZ3jeOs2yJxo4nF5lltbLc2qVsLSn7HCY3G4rMc2WJ/e4enRU3jZS\
w9CFCCwmFwf1GE/wAp+j19LTGeFeH4jhgMXLw8y7iiWEw9XBf2iswyDLpZjNYTN83yLhfLcrwTwrwWX\
YnETp0KuLrV8VUnW5cwr11VqS/KX/gh7efs06VYftYeFf2pv2ifAf7MeqX3gy0u/gt4y+KHwn/af8R6\
kLa3/Z+/aj8G/G29+H178Hfi74Z0fT/EZ+GPjWfSYtA8XWniCLxpqPjKw0Pw7oWqapJLpmoSf8FfP2g\
fhh+3R+1bP4k/ZM+J/wC0Z8YtM8RfFH4v6rZ6F4s8Tal4X+GNlqGm+N/ij8R9Fvv2ffBHirwjZ6l4S8\
Kp4ftJNR1zS9Yt9I1XVPF17qNzpsDJNHOn6/ft1/8ABu14i/Zh8L+APG978ZfAvxe+Gut+IH8KfET4g\
a/+zZ4w0bw18F4tYu/Cy+HdY8W2WkfGrxTql74Xv755zNcWOnSiC58OWVqsd1qGpaRBP/KB4k+Ffxa+\
EviX4qfFaLXrzwV4fT4peMPD/grxH4OsnsPGHxD1eH4neKPD2reGNA8RabFf3/gWEeHfDPj2/uJJ5Zw\
sej2tpdxXQvrCQfecGeCPit4sZ3lHHee+E9bLeC+MM1gsbVyPH4XHVfYYbGqWNwuHjVzPHvLsfTpOpV\
ws84p4b63Wq4XnqYutj8JUq+pi/C7g7g/h7w38VeEPEDM/F7wv4awPFGDji8Bg8BluJy7A4h5RPiTE5\
osXluHxlOcKOSZfl2Bw+ZYnFulRxuDnhcBXoYvA4DH/AGv+xp+0N+018Afhb+2r8DvhRb/FfRB8U9J1\
T/hYNrrsf7SmmeIYdE8QfDD9ofT9I0Kz8J/DT4w+HbW48balqfi/wZf2l/faZe2sl9pFq91DcaMNSs9\
a/pm/4JMftL+N/wDgnJ+1H+1n4Q8X+DP2yp/2CvGvjT4CeFbTx3+038LP2mPhdq3wp+M914O13xVrWo\
WfgL41ahrv2XxHN4B1TwTJ4o0+wml1rWtA8P8AhrxFYxfZrOz8PXf8sXwmuPiZ8Obu88ap8btZ+IfxN\
ttNsLS7+DJ0L9qP4heJ/izJp/jfxf4Q8T+P9b03XPgtYHwN4U8I2D6do0sN5qS3M+vWtr9kgvUa/h0r\
+vz/AIJTft7/AAR1zwT4/wD2XP2qYdP8Zfs3/tLaz4V13w/8TPF93rYtNHOofCr4O+FfCGk+M7rWNt1\
4X8EQ+FPAvgJNA1a2FhdeC73QrSaU29gq3vh/+tsJ4U5NhcBkUMJw/mfGWW5RnVfCZ1w/Sjl+HxeOy6\
jw3m2Dy/Ocvx2Ar4mhj88yHL8odXEYKP1eVTMK6nisFSjjqFGX61wv4K5DxJ4c8UcV0cizLjaOEoPGc\
U8G08VgsRm+My2eLnDLM+4axVLHYt4TMMiyfMqcquV0vaYTNK+AymbpTpYrD18V+3P7BXiG28RaB/wk\
HhvWfD3iDQNd/bS/bj1vRNb0jxHZajpGsaTqn7eH/BUXULDWdJ1Kw0qWHUdLntLiO4t7mKR4Z4Zo5k/\
dyKqlfjv+yB8avif/AMEzfi/beEfiivinxd+wB4u/a+/ak8CfDnx9L9s8UeIPgprfw5/am/4KA/DIQa\
21j4et1ga/m8Ka7ruqaJZWflX8Nzda94Zgk1a18SaBdFeV9IrwK8QK3iZnmbcD8I47xE4TzzEY3FYPM\
cnwOMzCmozzDFe0wmM+qUaywmYYSop4fGYWqoShVpylT56Mqc5f5m8JfRq8U6+XYzPPDfg/N/FXgfiT\
GVsbl+a5BlmMzWkoVIUFUwWYLAUK31HNcBWU8LjsHXUJwrUpTp+0oTp1J/10aezeVcfupx/xMrvg3Gq\
kjHiLUiMl7YE5PAyPlIzFufIq4rHMn7ub/XQf8t9S4/4mVwcHFvySeAThgwLKDMWQZVncpElwjPqDH+\
0JXyml+IZBi48Q6j5YLKzYZcgspO5GyoEcgY1ZW9iLS86lxPbqf+JP4i5LarcxA8L2dS3OT83BD5kb+\
RKlObqVWqc2nNdJ94/8A/OtdNvwLkTHfa/u5jiG1wBPqQLYgveVKW5Kg5JATKgKQhKtIVzbVjt1EeXM\
B9sT5jPqRU/8U1YDKo9uI1GOcKxXAKk+WWYTQ3sTSWYB1IF4LRlP9j+IvlD21+yj5VB4EbD5So+f5Qo\
3K+fBdRpDeys2oMk1ykiIula+5RR4atCVdRuETYicbSicMG2mNgr3Cm71VyTu4xtpP+ZB0Xf/AIY3JW\
O+6/dzDMN1kGfUiVzBZcsXtwWAwCQ+FIYByFWMsMxzH+7m/wBdP/y31Ln/AImVucDNvwQeCRlixDMBM\
FQ05r2JZLwE6kSkF4zH+x/EXzBLawZh8yk8iRR8xYfJ8wYbVQa9iDRc6lzPcKP+JP4i4K6rbRE8r3dg\
3GD8vJL4kXKNKXLS/dz1tbSf8o++34eQRM39o337qf8A1GlHP2jVcZ/tnWTtx9m27s8Zz5m75tvm/LV\
xGOyP93Mf3OmcifUgDidsEBbfADdFAyqnmEu2RWVHcoL29l36hsZdMhCjS/EJcOmtashdow2UXdIpDF\
AWIYK5kVnFlL2IxxHOpAGDSGA/sfxFwJrllQcKB8pGeAB/zzEZ+arqU5OTtTm1en0n/LT/AFEr+X4Fy\
3Y4g/dzH99H92fUlz/xLVGB5VudpxzlcsF+UAw4evwM/wCDgkn/AIZz/ZeGxwP+GmPjB8xku2X/AJRY\
f8FFBjZJEI8kcghtwB2qDGAx/ee2vYmW3wdSXdPEo/4k/iLgnSllB+RV/gO3jB9CE/d1+GX/AAXd8Ue\
BfD37P37Out/EDW9D8O+GLT4xftRRvqvjgPofh+217UP+COP/AAU2sfBsbaj4ilhtItXl8YX3h+300Z\
EzajcWq237wxx15mb1PqmWZlip0pyjhaEqjVpK6hFysr6XdrfmceZRrTyzMKeGw88XiZ0Kyp0qcXOpV\
m6TUKdOEU5SnOVoxjFOUpNJJtn1p/wV0+K3ir4I/sI/Fb4q+DfENh4H1/wb8SP2XdRj8e674R8RfEjS\
fhzpk/7WH7P+neIfiRqXgXTri0uPF1p4d8O3mqa09iZ4o7gaKI7gmABZP4wv2df2sP2qPh5/wSE8C/8\
ABNa68O/AvwH4A0X9oTx98NJv2y7/AMdHxF8Ik0+DxJ4P/bKi+C2mfEzRNU1D4Xt8ftS1bx74hvoL3U\
PHFlpEfhjwZfaENHufG62vm/1ofHb9ob/gln8Vfhzrfgvwt+1B+yF8OvEh1rwV4p8N+N08K+BvFv8Aw\
j+u/D3xz4N+IOj3i+G9Skgg1XdqHhxIhHcSmEeczyxXEYEB8nsv2pvB+l2en6bpv/BcX4D6fp2nxLYa\
fYWP7PfwVtLLT7KzurW1tbaztYNeVLa1SBI2jjjVVRYFUDhWDXG+L4OzfAYzhfh2vnuKw2NyPNKWYU6\
scJXpVMnq5nN5epQ4ryuUMNinjKNbEV6VBZjSnh8PLLc1y+SxdPE/014YYPGcF5tw3xbLh/F4rPeE8z\
eOw2Hx+DznC0Y1aU8txOFxMamVZZi8UqlPEYPlUqePws4wdTkhGpKnXh6J8Uvj145/ac/4IVftafHT4\
haLY6Zr3j/9jX9tK7sbzQvCfxB+Hvh3xh4I0ez+Nvhz4Z/FPw54K8eX+oaroHhbxh8N9H8KeKtNtr/U\
b4Cx8XwPFqF5DILl9X/gof4H+BvgH4/fBn9qnT/iF+3d8P8A9syH4MeO/hl8PfCn7AHg7Tfi98WPj/8\
ABvwtq1j4g8TeEfE3wm+JvwV8a+DdS8IeGvEnxGttSttR1y10WysNS8ZwN/as9+dHS1+Q/wBo39oL4O\
fE74I/FD4RfFT/AILofC3/AIV58ZfCOv8Awi8Yr4c/Z5+GdxrE/hr4i2er+FtfjsptD1C6l065bRr+/\
aK5eJo4pp485kZRJ8FaB+2qfix8a9L1743f8F0PhR8Ev2kf2db340+FPgJ8TPhV+yFofjj4PfGz9mb4\
oSfBPWNa8bav4e8Y+F5IvA3iifVfDXhzQNU8IyeIJNe0XV/BF5q+l6rqnhXV7G7v/Wp5ln/FPhPl+TY\
DgbMsTmPCWaZlmOKnWq5HaVHG4Xh7D0sVhaFPPZVsTVw+IyyrOvSw6lUwvtcPXnJYeOJr4f5PL+FpZP\
x5WzKpjKuR5HmXtabpUMPn1OVLC4yWJw/1GviP9Xm3h61LErC4mawNRYjD/WKdPDVK06eGqfbfwZ/4K\
I/sMfso/s3fEWH9j7XP2m/2sf2svH2t+IvEXxX1f9pPwR8fPEX7ROp/EHwN4I1DS/E+rftR+L9Y+G2k\
Qro3wy8F+CZdHuNA0IwW2laf4LGn2aafp0mq+JoPx4/4Kh/8Fqf2g/2hv2Ef2hPgr46+Dfwc1jwv8S9\
M8I+GdRsNK+HXxns9Yae+8feDU0u50e68R+NdQtYdYt9VjsLm0eWznk+0WsSwhZPLZfDfF3xR+Dv7MP\
hb/gqtr3wd/bt8KftGfEHxzrfwrvfDni34ifsxeH/FvxA/ac1D9otdOn/aR8QeENdtfCwbwPPoM/jDW\
JJ4PD1vbWTzeCrCRoYFsY/J/Pu3/bV1n9qTWf2XP2ev2ho/ht4Q/Z/8HeM/CvgLVtetP2Zdc8KQ+H/B\
nifxT4UtfE/xH8aXnhLw9o934k1/TBoujeIXvJ7+F5dSstQu7mSVLi4WT63hLxv8PvDDIlwxxD4TPOe\
OMbRlWwuLxWQYbMY0cRVwVWWCjh6n+uCwKw8Mxhh8HKlisrlKD+t4zGUcRTjSwD/0q4I8Jvo+f8Qu4v\
weK4Gp59xbnOURxFXijOOIaFfOcvzLNODqOc0sZl+XvLMDSksHmGPwVGnl3M6+GxX1ynjs0xGLwc8HT\
+av2vPiZo3jH9nP/gnl8Pfh/wDBD4XfBy7HgvSrjxr41+GXw88Y6VqfjfUtf+C/7LfwV1fxv8Qotd1i\
603VdWudN8GeFpbhtMg0vSrzWvEmt6nd2FzqXiW9upf0Q8Ex/A6Hwj8WPEug/sxfCPR/jp8a/ht8bfC\
cvx9l8OftI6v408FX37U37Mdl8BPjHr2gaZZfFq20HXm1Kx8R+N9dS31bTtRtLHWviJrL6Iml6XLp+n\
WHzN+3/wCDP2VdL+PfhD4S/BH4tRfEz4V/C34kaZ4c+HHj/wAEfDe88MaBf+DNR+E/7OOsPJHeeI/BX\
iyXQdD0nxdc+PrGXUl+1mOTw9dNJbXQtLW0j3Pg5/wUM0r4c/CLR9E1j9lP9nT4gN4M1EeF77xj8QdO\
/a60Dx7rk+oX3iDUNEjv/DHw3/aP8O6fdwWOh6Klg93pWhRQW0Fppw1a5k1PULe7v/1Lwq8W/CPj3xU\
4hwmY+G+GynLcvymPssNmHDOHpRoZhSxWDp5lONOHHGFo0sRVxseenXwmZ4qGIhT9tDD4J81KP0HBeV\
fRly2OfcQce8C1+LuBuIsFw/SyfLo5jgqOIwEXkUcLm9SeFxOa4J4CrjcxpYnFV1WnHMIrF0IJzoOMM\
P8Af37Rv7Vf7RP7V37Tf7J/7UXxbufghpPjD9kf45r8f/C2j/Cr9nL49+GtI8eeOZdY/Z9mlHjyTx/+\
0D4slj00aT+zT8PdPhXQ20WSOFry5eSa9uGnH612X/BwP+1hDBYRr8L/AIGkQWlnEm74Z/tAMxWK2nj\
UtJ/ws0ENtZs4xjGAAGcH+c9v+CrfguMkP+w/+ympby5AH0//AIKFKdjMbhCAf2txlGjkXBOcrhlIYl\
zHH/wVc8ERrEv/AAxF+ym/lRxx5ex/4KEbpPLR03uU/a3GGO/J27RlRtCgsG/o7LcF9HrKo4r6lwLk3\
+1yUp+1ySWJTac5Nw+seKtVU+adSpOfs1D2k5uc+aT5j7LA4v8AZ9ZbhcLl0fo85ji8Jgubkjjs3ynM\
J03JwTjCrj+KcTWhC0FFU1UUIqKSiktP6JdZ/wCC+P7THiPQtV8OeIfg1+z1rvh/XdNvtG1zRNZ+EPx\
y1TR9Z0fVNHl03U9K1XSr74kPb6jptxp888U8E0bxTRTPBIjQMUP83/iLwNof7Ufw+074eXF74X+Dnh\
W0/a9/aP8AiDDcXXwk+JPi3wv4XsfF/wAWPij4UvdG1jVNKS58Z674I0nStRs57W1udU169shpd20Fn\
dalquptf2dW/wCCrFo1nFJ4F/Zq+BPwg8Y6dqei614b+Jnw3tP24YPHXhDV9C1Ow1Sz1Tw1ceMP2kNY\
06z1HzbAKJ5dNnlgFw0tm9tcpbzw8T+zt+3P4g8XFvAPxSuToHwX8S/tCfF74teM9R8EfAzVr9PAOo/\
EH4meLzr3iHwBoGmx6dpXgyyupta0CzutGsbrQNGvv7A8P2GsSQf2DpFxpX6v4d59wjSzdZJ4fPJeD6\
udwl7d4XIszpYmi6FfBqnmFNZXxpmMaNXCyrc2GxkcVh8RRlGtHljCcZy9nJc8+hfic8p8LZL4b4bgr\
gzjXKs1y7OMLisyw1L6w6mNyCpQryo5fVzPCShTpU8WuepiKdWVNYmhWpfVKk/bYfh/4EeNvhhdeK/G\
/gDxX4K174hap4Z+ImlTx+L/ANlmXUbO+ufFHjPSfihoMXhDULnUUvPhfqVh4y0qxFrqGnXhdbe9vbO\
4WbStQ1LTb36n+F1x8PPgn+yxpdx8TNV8RR/EjS7P4eeCPBfhHw1pOq3mp654h8L+B/h14d1Pw5d+HN\
X0WzW+Ov3d7qx8P3+j6xqFzaXfww1K01rQItN1mx8R6X2nxC+LfhTwPbXHhy41M+IdL0zxxrWneENX0\
D4ZeK9FvviJr+uR6JpOnWXh3WvGXgzRtZ1Wy1KLw1YzaPputmyTTftl5dNZaTPe6vI979n7VfBug/Fe\
y+LnxW8C6T8corOJfCXiP4VeLLTxT4e8O+GfD15qWi+Idb0f4a+I4dL07xB4D8bXVmmgiXxhZvDqV6l\
s9lNbDwvqWq+E7r+leBfoy/6hZ1lniDPF16WUZJiMTmcMlyrD5vhJ5tjatLHU5wjV4iz/ADajgqmLjm\
VT65JRwMJVY4bD1sT7Oioy/o+WVcF8JVszwH0d1B+IeZYajTq4V8QrHYPBYKnLAyWMr4LM69OdbOMXl\
+SYKnTy5YrLp5rXwdGhnGaYDL/rmc0vqD9hr4/T/DjwVe/Bn9rC38d+LP2bPiXe+ItX+Ifwj8L+Jbjx\
RrPw9+3+LPjn8RPDVh8IbzVtb0zTvCuuL40+Mkz63fWTQ+dcWJ1PTpBqdraXbFfQnin9hjQpfhN4Z+P\
nwd+OMXxP+DHinS10W78Z6v8AD+f4fn4VfG59dsrax+Enx/tZvG+p23wl0/ULC+ittO8Vy31/oC67qe\
k22sT6L4a1rT/GUxXfmz8MuO89z7i3K/EfNuAMXmmLrRzHC5XnGY8MU55jRk4V5YvAV/q1Z4+nH2dGt\
OvB4j2EMM6ralCpP8qwX0dvojcWzrZzk3iTn/BGOoxo5dmv9n8W5zwTVzDNMrpxwNfGZxlVGpktJ57K\
nRoxzCqsBhqkorDzlRhCpSc/7fNPhkEVwDZwKRqV38otLZQN/iLUlXCjUCBvI2nk7gNrbANxuLE+ZP8\
ARYTiaAEfZYDtJ1K4QKP9N+UFgUIGQVQISqgSNmad9l8mfb0/tK+x/wAgb/oYNR8z/V/L9zHT/tr+7x\
V4fZsyZ/56xY/5BX3ft027r/0x2/d+X+9+42V/z41eb2lbVfxF084+Z/znadv6+4liicvagWsLbobUg\
G1gYSBoL0hmBvRvLBSSSVLGIEhSqq+baxOF1FjawqDeIRILWBWcf8I1YNuaQXpZztBbJRTlQ2NwCNdj\
+zbrfd08q33/APIK+95N1v8A9Zx97y/9Z83/AD0+fyqzbT7N/wATPH+s+3R7v+QV97/hHdPx9z95/rN\
v3/m9P3uyrgp/vveVuRdH/PHzDovV/oa8sTh7oG1hXbDdEgWsCiMLBZEsoF6dhUMCCCxUykgMWZUGif\
Mf+iwjM04A+ywDcRqVuhU/6b8wDEIAcAK5QFlJkWKT7NuuNvTyrjZ/yCvveTa7P9Xx97zP9X83/PP5/\
NoP2bMeP+esuf8AkFfd+3Q7en/THd975f7v7jfWMVLlp6rp0fb1BW1/rqiCKGT+0b4/Y4MeRpS7vslt\
nP8AbOsp5e7+0M7d3ybcbcfJv2/PVxInKRn7LCcw6Ycm1gJIedgrEm9GS54YkAuBhxGPmrMi+y/2nff\
3vs2lf9Ab/V/2trP/AAL/AFX/AGz/AO2VXl+zbUz18qwz/wAgr73nN533ufu46/N/z3+TFXVUuZ3a/w\
CXfR/y0/MNOxLbxORBi1hfM0YBa1gfcTpquFO69XcCvz4O0FjvJDfu6/Fn/gtfG3/CnP2c2+zxY/4WX\
+2V8/2eHd/yhM/4Koyff+1Z+7+8+797959/91X7Qw/ZsRbv+ese7/kFfd+wjP8Arv8Aptn73y/3v3+a\
/Fn/AILX+R/wp79nP+//AMLL/bK/6B3/AEhQ/wCCqP8AwP8A13+ftFeHxIpf2Bnmqt9Ur9P+nc/M8bi\
P/knM+/7AsX/6jzP2rlicPdA2sK7YbokC1gURhYLIllAvTsKhgQQWKmUkBizKg0T5j/0WEZmnAH2WAb\
iNSt0Kn/TfmAYhADgBXKAspMixSfZt1xt6eVcbP+QV97ybXZ/q+PveZ/q/m/55/P5tB+zZjx/z1lz/A\
Mgr7v26Hb0/6Y7vvfL/AHf3G+vZipctPVdOj7ep7Ktr/XVH5a/8Fc9Y8ceHf2f/AIG6h8NdH8Jan8Rp\
f+Cgf7AGjeALDxxc6hpPgmfxv4j/AGtPAPh3wqvjG/0CC8vrbwomvajZNqP2K3mujZ2siW481Ymf8F/\
+C262f7ef7C37C3xr8eWvgvSf2k9F+N/xn+BvhP8AZZ8Eah491rxZ8aPjN4a+Nlr8C/H3iD9m/W/Cel\
t4hkTS/iB8E7a702a80nT5Z9K+IdnpV3qdlr17pmh+Jf22/wCC23wz8T/Gj9jLQvhF8PvGE3w88f8Ax\
N/ao/ZT8C+AviBBe3GmzeBPG3in45aFo3hDxml94cuIry2OleILzSL7dbSK+LAhTtMIP8j/APwUJ/YQ\
+On7BH7O3/BOD9nz4+eN/AHjSXw58VP26PGHgHQPAPiXxP428IfDbwH4m8Nfsp3Nn4O0TxF458H6Je6\
lM/xI0/xz4nn87TLRbS88dyW9t5iW0cz/ADPHcl/ZtR43hzGcS5Ll+S18xxVHB41ZdUlHLMdiMdaOMh\
GpicO6dKjXxM50aVRSo0KkG6UnCT/uj6HGQf214l+CdHA8VZZk/EWb8R4vJsHhMflSzdVcLm+T5nhM1\
xFXBYzC18nxmCUJ4PCV8Pi6lDEweJjUwaqSdSrhf1X/AOISrwz5Pmf8N3fEzHr/AMIf8XMf8eP2vr/w\
2Bn7vP3enP3v3VR6h/waV+Gra0vZR+3V8TXNvHckRnwd8WfnMWnvd7Dn9sQjJC98rg53E/u6/NLVP+C\
R37R+j+If21/DFz47+CkmofsF+AfC3xN+ME0PibxY1n4m0Dxp8I/Evxh0rT/hzI/w1STVtSh8N+HbyC\
aPUo9FRL/7PCLmaN5bkeb6N/wTc+N/if43fsz/ALP1h4w+FcHjL9rb9nnQv2mvhvqd5r2uxeF9C8A6/\
wCA/HPju00Pxpfp4EkudO8Vf2T8Otcjnt7Kz1O1S5v7eOPUSrPLbfyq85wFPEYahPwdx6qYiv8AVoR/\
1nzf366xjwHsl15vrdOdD/HFq5/qtQ8L+KcZl+Z5jhf2g/CGIwmU5as3xEo+CPAFqWWyyChxRHGSfNp\
RlkOJoZkpK7+rVYTsek/tpf8ABvZ4e/ZW+Ov7Fvwdu/2vfi/8Q5v2vPiPefBeTxXLpev+FLjwHpg8Zf\
CrRJr290+L4v6m/jq3eb4tyXBtJbywGzREt/tJWZTaeLeOv+CLPwv17Vp9A+Av7Q3xS+Mnw717xLrvw\
m/ZQu/COjeN7XXv23v2mvDl/eW/j3w9+zx4a1z9pC/0uy/ZT8DWU1zc+P8A456nd2/hbS7m1vLPRLbx\
BFF9tu/uzUf+DXP9t7Unvftv7RPwLlju451ubaP4tfEmCyljeKNZIRY2n7PiweSySMpjjj2sCVCkhwO\
i0b/g2Q/bS0W5mvk+Lf7LF/fzwQ6et5e+PfiMr2el2UkMNtpWnW2nfAOC30zTVZTIY4YY1kdjK5dVBT\
7bJaWMyvF5njs08GM04io4iVGWBwcc+zLB0sFy0IQqqVSlaeL9tWU63tKvLKjTnVo0YqpOniMN+WUuK\
PBbMsm4byHGfTB4GwWZYTD4jD53nuJ4K4XxVTPHLNMTjsHiHgIU6k8reFwsMrympgsBjo4XMMLQxVfF\
1I4mdCpS+IPhz/wQy8OfDH9s6b9hn9rD9qD4p/AXXPGml/Dyz/Zx+L8PgD4xw/AL9oH4o6j4M8J+Jfi\
18NfAfxAvPjl4Wi13xDpHivx5pvh7R72aO4/t650ZdOuR4b1y70Tw1qH6z2P/AAaV+GZ4LBz+3V8Tk+\
02lpMIh4P+LGU+0W08wUbf2wwpA8k91BCHhflD/iT4x/4Jc/GWy/bt1b/gnh8bPjD8IPhr438Sab4J1\
X4NeMPG974s8OfCb4pan4k07S73T9H+H3xBl+CctxqGvXmr3GvaJYTS2Vlpt7rfhbWPDNvfT602naff\
c98T/wBhz4wfsg/GPVvgL+2B8SvAPwh0uy0iz1f4dftE+IvCH7Qes/BT4w28WheA9d1Hwv8AD7xH4I/\
Z/wBZ1HxX4k0yz8eabBrE6aUbKxvLC/sr3U4r1NObUvqM24Pz/N/qlfLPo3ZvSzXF4PD4qeHocS5xOO\
KpypwX1zB01CEnzN3xOHg6sqdaNWcHyOUKWuUUsHPM+FuE+GfpucO5FlNTKJ18LWq+EXBec1MasLiKt\
OrioUsTUxePpYTF0406+BTx2PjyylRUMuo0qGFj/RSf+CNfgL/gmN+yX+1H4vu/iN8VP2tNW+Nup/s6\
/Bbw78ONX/aP/bE/ZQ+F11qfxd+Jtt8BYbf4vS/B39pTW5fiL4Ce6+PNle6hYXelXD/2d4evtPszC2t\
XLxfyz/GH/gmX8W/APwD8S/ti6H4LNt8Cm/ah/al+D3jzQfhf8Rvix4p8Pfs8eNfh3+0n4++Hll4fuN\
X8V6qmsa38Jr+4ttMtfD3irVgb+5vJ49L8TNDrd5pd34i+qp4/gtp37If7Qv7Pfhb/AIKOfs66brfx2\
+K/7O/iPW7WDwX+3FpHhPXfh18IfCX7Q6ap4e1zX7f9h+5v9P1WH4o/EL4QeJdJWPT72GS7+HLNPNZP\
Fbmb9vv+CUn/AAUr/wCCTn7L37EHir9k34sftH6T4w8Naf8AGj9rHwmIde/Zv+NWpaB8Vvhjr/xa8X6\
RpniHxH4TPw01q3t9O8S+HftN1qGj393d3ESazLaXxllacyf1T4D574ycGYXKMFX4I4iyPh/KMvxP1b\
JMZXzPF08PLFZvGpj44N11KrGrViqWKq1eSMIyqU48lWKm1/Dvi/lOccE+NvEXEmDxf/EwuaZniHTxO\
PwXBM+H8FmmWYbKeE6ccRSynBYf+x8BXw9atiMBhamApYivWqZfjMTmMqHt1QxP8oHwc1vWLPxJ4K1G\
81H4x+J/hJ8H44/EfjyGePX/AIyWvwX8H+OPEHw9+GfxG8feDfDniTxdZ6b4e1HUSnw30uC7lv8Aw2N\
RvW8PeFNQ1d7YWstx+gvw/wDEPhfxtrPibwv4e8eeAdT8D2Pxo1Kxt/ida+FdbstLC6n4Z+GGhah4l1\
e7fwJD40uvBsenaHpuo2elX2lPe2NtfXVxp+hQX+r38d38Vftk+Af2X/h/8cfElh+x58dZvjz8BdUc6\
x4L13V/B/jzwZ4v8MWd5IzN4N8Y2Xjjwdo/9q6vYvujTUdPie1v7dYrp47K4kmsYOU+Dvxl8f8Ah6H4\
jeF/h9pnja7+BfhXxb4C+KXxJ8LapbaV8R08I6xJ8OvhF8KvH3xH0/xJb+EdOb4aaF4g8ba94ftlt4Z\
LK2u5G8D6D4k1DxRfaBouoyf65+GXjPneTYr6pxHmdfNeFsZQoqhKvKXtMq9vWouOIw0MZCdajKUsRV\
nWwM6dGFOVStF4ejXVWlX/ALd8KvEzCeHef8I4COX0cHwVxRnEsZU9jhKOAqYHGYvI8bhnmio18Mq/1\
2rScKWIw2Jo0nGnH2M6VGrSlQr/ALb/ALKH7Vnjr9lLx3qGu6Hpek+N/h540sF8LfGP4N+LIbe88C/F\
nwNcyXltfeH9fsLuG4ht9RSzv9SSw1A21w1ob+4tp4L3Sb7VNM1Erw79rrxT8H/gv+zx+y38Z/gt490\
r47/D/wCOWgeJru50bRtF0TR/iH8Mvjp4C0j4Qab+0N8O/iHqknh631ibQrG58SeHtV8L2VzBPIdO1i\
WbTdNkg1WHxH4qK8XxD8a/oM53xPjMTx/x3Qy3jHDqNDGQwmL4pwFdey92jHHxyZ4WnWxEKXLGM66qz\
jS5KdGtUw0aUn/SnEeU/RS8WcXhePeKoVoZtm9KpReKwWZ8UZJLFRy/G4rL3HGLKK+W0sXi8JVwtXCz\
niI4itQp06dKlXqYP6rUn/olWepW8aXCy6vp6OdQlfD6nYglJvEOovbOM2S5U7gynAGHDfvFIUWV1ay\
3S41nTcie3Df8TOx5Y6rcqp/49ef34c54xncQwIiU09m8q4/dTj/iZXfBuNVJGPEWpEZL2wJyeBkfKR\
mLc+RVxWOZP3c3+ug/5b6lx/xMrg4OLfkk8AnDBgWUGYsg/wAc6nsvaVb0ZX511j3j/df9fj/zAa6e9\
+ZTh1ayMlnt1nTQTBaGP/iZ2Iwptr8xjJtTtwgl4IfG7BLEhkz4NTtUhvXk1bT1hluUkg3alZAPEPDV\
ohZB9lBK4jmT77fMpXcG+ddyJjvtf3cxxDa4An1IFsQXvKlLclQckgJlQFIQlWkK5tqx26iPLmA+2J8\
xn1Iqf+KasBlUe3EajHOFYrgFSfLLMLgqV6v7h25Y9YfzLy/Rh0Wv9aE02rWQkvN2s6aSILwyf8TOxO\
VFtYGQZFqN2UMXACZ24BUgs42rWW6LOs6bkz3AX/iZ2PDDVbZWP/Hrx+/KHPOcbgFAMTXJWO+6/dzDM\
N1kGfUiVzBZcsXtwWAwCQ+FIYByFWMsMxzH+7m/10//AC31Ln/iZW5wM2/BB4JGWLEMwEwVDlH2PLS/\
cS6dYfy+n+Y9ddfz8jKj1K3F7eynV9PELrpkaudTsQjTx61q3mBT9i5ZZJI2OG4EisUwRHVlNWsvLix\
rOm48jSCP+JnYjCtcsIBj7KcYfPGTt6kyj5QRM39o337qf/UaUc/aNVxn+2dZO3H2bbuzxnPmbvm2+b\
8tXEY7I/3cx/c6ZyJ9SAOJ2wQFt8AN0UDKqeYS7ZFXU9lzO9CW9PrFfZp+T/rXyEr/AM1vvKdtq1kVt\
9ms6aAZ4gv/ABM7EYY6UrKebVsfuMDJ3f3cE/va/Fz/AILVahbT/Bz9nNYdTsZgPiX+2RlIr+0kYb/+\
CJn/AAVNjTKJbk8rLHGPm5aRYx85EtftfbscQfu5j++j+7PqS5/4lqjA8q3O045yuWC/KAYcPX4s/wD\
Ba8n/AIU5+zmPLl/5KX+2Vz5t9t/5Qmf8FUR93ydnT5uv3fl/1Hz14fEnsv7Az21Fp/U62t4/8+5+X9\
eZ43Ed/wDVzPtf+YLF/wDqPM/ZqbVrISXm7WdNJEF4ZP8AiZ2JyotrAyDItRuyhi4ATO3AKkFnG1ay3\
RZ1nTcme4C/8TOx4YarbKx/49eP35Q55zjcAoBia5Kx33X7uYZhusgz6kSuYLLli9uCwGASHwpDAOQq\
xlhmOY/3c3+un/5b6lz/AMTK3OBm34IPBIyxYhmAmCofZj7HlpfuJdOsP5fT/M9rXXX8/I/KD/grv4t\
8RaH+z/8AAq++H/ijwFpHjh/+ChX/AAT40zwtrfjyKfxB4J0HXdc/a98AaHYa/wCLtF0TWtIu9V8N2N\
1fyXd7Bb6np8ktvbSKt1b7w8P4r/8ABULQvEv/AAUT/wCCQfwg/b98a/EHwL4X/aE/Zc8YfF/w5aaX8\
D7tNd+CXxQtr79qJ/2adfn8IzeJ9ROpWGj6lcfCvwfr2j6hcajf26add6hYXtlfrqdvf6T/AEe/tufD\
/RviV8OfAPh/xX8JX+Nfgq1+PHwu8Q+NvhzceDG+I2n694a0DW9a1O7g1Pwnq2mzWmo2/wBqhs1T7Wg\
iW6MJLJK7FPIrXwH+yFbaHZ+Fbb/gmfNF4Yt9EtfD8Hhq3/ZE+HMOhDQYdOn02LR7fSIrEW8OjHT1WJ\
LVI/IWC2MKp5ZYDpzrhnijN8mVfhdUOTNcpzTKKyq16SdN4tV6Mqk6U6co1ILD4yrD2V6ftY1Jp1Yck\
JH9B+EHGlLgPNvDni5YbF5hiuEM/wALmbjgqtHC11gqFWccywNHGTq+0oVc4oVKdJYr2E5Zc8HTr4eN\
Wdeoqf8ANx+yR/wVM8G/tP61/wAFVNL+KejD4bftE/txfsl+GfCHw18EaCl1qnhTxv8AFv4Pfss/EH4\
R3XgrwXNcxS6ha+I/FviHXLJ/CuhTre3DXd0PDDarqGt3GgzeIO0+GH7RXw5i+KH/AATc/wCCg9lqt9\
rHwG/ZH/Ze8BfsPftTWuhW8OrfEv4BfEqL4XfF34aeG/H/AI+8CWcUlw/wQ1+9+Idjd6F4j0o6mt2nh\
/UtGltbfxZHaaBe/nv/AMFSf+CT/wDwobxxP8avgF8LPit4E/Zk13X9EivPEHxI+HniJYfgFqHiDU7X\
T49G8Z6tpNhrF5rvw6S6vLb+xtXeC91GWG6j8OavbanqX9n6j4g8U8UfC79uT9nn45fCHxZffAr9mnx\
N4m8ZfDbTpfhvf/8ACqPFvjH4N/t+eF7uz06C+0JNF1bTRo/xQ+IGq+CfFOhWd7DZwaNqniSbT9L1+x\
m1D4ieINK8ReLP50464fzrBZx/bWEwGGyangsxqYivlVTEKvicqxuIzb+18HyT5KUcxy7FYqWIq5ZVp\
qKxtDnyOrWw2eYenLEf7I8LYbwvzzhTF1+EcdUzbLvEPh3+y8MqVaVClisry7ganwZmuSVoyp4mpk+a\
4PhejgKWPqupjZ5LmOEw/Eqw+d8NY/E0qP8ApGaR4z8L+KNHsvE3hvxj4Y8R+HPEOhxa9ofiDQvEmja\
xomvaFq2l6VqOm6xo2radG9vqulXWm3NnNb3EDmKeGVJIpNhDyaratZbos6zpuTPcBf8AiZ2PDDVbZW\
P/AB68fvyhzznG4BQDE3+dh+yj+07+1N8B/hJ46+JPw7/Zo/YO+KP7POo/E22HjrQ/ib8EfjD8WI/2J\
b7xrrMun+H7fVNUbUn8T6T8I9baWFdJnutU8WW1zc6C8EcqeLLzVLfWf2t0Fv8AgqJ4r0LQ/FPhf9gn\
/gj74k8M+JdLsNf8OeItA/Zh/aP1jQvEOh6xHa6hpWsaJq+nzSW+q6Tc2dzavbXNvI8U8V2kiSPvR6/\
eOBsNnHHWCnVyt5F9ZwSpyqU5Z6oudKrGXsMXQvlz9phcTGMvZzTcqVSFbCYiNLGYbEUKX+U3ix9EzP\
vDDP8AMcJi8/8AZ8PRxlbCYTGZhh6eAqzrUadCvVwmKoVMW/q+Pw1LE0JV6HPKFSlVo4zCTr4DFYXE1\
v3D/bp/YN/Zh/4KIfDTTvhv+0DFKlx4V16HWvAvxI8Ea/4d0P4nfD++vdXSDxBB4V8Q6r4c1G3XRtYs\
bGO01bTr2xvNOu1gtL5rQappejXmmfKNl/wSTszHpyy/8FVv+CutvO9pYl4E/bwiiFu72l2xhQN8Lcw\
KhilUKVJQErzvJT4AGhf8FYct/wAa7v8AgkofnTI/4ZQ/ab+U/aJAqcesm6PnnKcESbmNbT9B/wCCrv\
2TT/I/4J2/8EmDH9js/ISb9lD9pszPF9mfyjKVOTI0e4ttOMwnbgb8/rOD4e8U8BgFgMLjclhg6E5Sp\
05Z9SqQpuolz8iqZbJQU3FSlGNlKXvPW7l8llnDfFOUYChlWA8TMFTy3DSqTpUZ1cDWp0pVXF1fZRrY\
ifs1UcVKcYcsZSvJrmbb9M/bo/4J9+PPgJ+zTrPxF+Df/BVj/gqAfiNcfFP9m34a+HJfiH+2LrPjfwd\
p5+N/x/8AhH8GtX1jV/B/hbR/Dl/rxsvDnxB1S6t7eDXdO3XFlBHLM0AkEniH/BKf/gnZrvxj/Zs+JH\
irx/8A8FMP+CkfhXxrpX7Xn7b/AIM8Vn4QftYXnwy8J+Ldb8CftLfEDw3qnj668Ja14f167g8R67cWR\
1HUnudXvpri5vGaS6dl8yTc1Lwf/wAFTtZ0250vWP8AgnD/AMEhtV0q9jMN5Zal+yL+0jfWF3CbcMYr\
m0uonhnj2Ksu10I+UHHljbWz+xX8Of8AguJ4f/Zn+MPgz9nXwt/wS2/Zz0bWvjR+1wPDWlal4I/ai8G\
XPw18Xa78UPF0N9qPw88G23hq/wBBsvC+l+I5N2l2+o6XqVqJtLkh1azvUVoJN6GA45wWLxFfPuIcpw\
EcRhlRoezzChiKcJfWsNKrUqSjgabjzQ5Vb2U2lBtS1aMs3zHiDKqWGy6fHWUyzOrRx+JhiJPLlOVCn\
WymE6KVKnXqtQlJTjGKcZyqtNRlCHP8E/8ABa//AII6fGL4b+HYv2rfhh8f/wBoH9sHwh8PvDC6F8WY\
f2i/ig3xk+OfgDwhpNzca1B458OeJF0iwPiD4Q2dx4iv11XTbexW68NyLca9I1/o93rV14b/AJP/AIb\
/AAk8SftA/FjxJ8IbD4h/Df4P6Bql9HqGq+PPir4rbwR4a1W9fwf4et9K8A23iq40yey8P3+pX8Fpat\
falJa6PYrq0d5r2o6XosF9dN/Zz+zdpf8AweEaH+1N4l0X4p+I/wBlzxj8JdI1Txzpcfi748wfAu1/Z\
98UnT5Le08L+I/Dtt+zBoOlfFu3gvrWHSLrRo9R0zTXSC6RfEdhZ3we3j9I+Af/AAbEfADxBoHijVv2\
p/jj8X9b/aE1TxrJq/xXvP2dofhJ8JvghB4t8ReGPBXiLUdE+F/w/m/Z/mHh/wAH6Y2vf2ZZCGHTbe5\
i0qO7ttA8PQzxaBZ/0V4beJWXcH8IZzmnFnEWT5zi8prRy7BYXC1MRXzCtGrRp1v7VjhqWFpYVYLA1J\
UadKvXxNKpXxdSnThgcRDD4upT6OHfH3LMdl3DPA3ifVxv9k0sbVqLG5dCNF4vC/2fmtN5Zi/ZKlWpR\
qzlGc5YaFOdfAqeHrVKM6nPW/kp8afsh2XhT9nbwn8Y9E/aj/ZD1CI/EDTfhhd/CLR/i9qz/HLwbbtZ\
aq1t4p1fwRrXg23fV/AMdvpWiyvq2i3usLFLrFkrhb201OLTSv1O/wCCqP8AwRjs/wBhgTXmhQfGr4j\
/AA18Z/ELw9D8JfiZYNpGsWOkaR5Hit/FPw3+K2gaR4AhmsviGllHp11pmsWtxb6dqFr4ZvGttFnuL/\
ULbwaV/Cf0oJZljvFbGZ7w/wCGUvEzh3iXBYLH4PG0cu4gzKlRjVpKM8K8Rk+YYCn9Yw0qf1bEwxlH6\
9TnQVOu26cZT/3A+j3wfR484G/1m4Tll2bcKZlXdTLJriGGWQoYOpCnOGAjSjR5pSy+pKrhKsa1Khia\
FWlOhXpupTdWr/ogaereVcfvZz/xMrvk2+qgnPiLUgMh7kkYPIyfmJxFtfJq4qnMn7yb/XQf8sNS5/4\
mVwMnFxwQeQDlixKqRMGc09PVvKuP3s5/4mV3ybfVQTnxFqQGQ9ySMHkZPzE4i2vk1cVTmT95N/roP+\
WGpc/8TK4GTi44IPIByxYlVImDOeuq/wB5W96X8RdPOP8Ad/rU/wCa3tovv/4IRKd9r+8mGYbXBEGpE\
rmC94UJcAsBggFMKQxKAKsgbNtVO3UT5kxH2xPlMGpBR/xTVgcK73BjYY4yqhcEsR5YZTpRKd9r+8mG\
YbXBEGpErmC94UJcAsBggFMKQxKAKsgbNtVO3UT5kxH2xPlMGpBR/wAU1YHCu9wY2GOMqoXBLEeWGU3\
B/wAb3pfBH7P99f3Q6L1/yNKVTvuv3kxxDdZJg1IFsQWXDB7glQcgEvlQFBcFWjCjKcx/vJv9dP8A8s\
NS4/4mVuMjNxySeSBhgwCsTMVcEqnfdfvJjiG6yTBqQLYgsuGD3BKg5AJfKgKC4KtGFGU5j/eTf66f/\
lhqXH/EytxkZuOSTyQMMGAViZirjKL92l70unT+7/hH30X9NeZTiVv7Rvv3s/8AqNKGPs+q4z/bOsjd\
n7Tt3Z5xjzN3y7vN+ariKdkf7yYfudM4EGpEDM7YAK3GCF6qRhWPEIRsmqcSt/aN9+9n/wBRpQx9n1X\
Gf7Z1kbs/adu7POMeZu+Xd5vzVcRTsj/eTD9zpnAg1IgZnbABW4wQvVSMKx4hCNk1dV+8/el/y76f3a\
f90S9F9/8AwQt1OIP3kw/fR/dg1Jsf8S1TkeVcDcccYXDFfmBEOEr8Wf8AgteD/wAKc/ZzPmS/8lL/A\
GyuPKvtv/KEz/gqifveds6fL0+783+o+Sv2mt1OIP3kw/fR/dg1Jsf8S1TkeVcDcccYXDFfmBEOEr8W\
f+C14P8Awpz9nM+ZL/yUv9srjyr7b/yhM/4Kon73nbOny9Pu/N/qPkrw+JH/AMIGe+9L/dK/T/p3P+6\
eNxH/AMk5n3/YFi//AFHmftNKp33X7yY4huskwakC2ILLhg9wSoOQCXyoCguCrRhRlOY/3k3+un/5Ya\
lx/wATK3GRm45JPJAwwYBWJmKuCVTvuv3kxxDdZJg1IFsQWXDB7glQcgEvlQFBcFWjCjKcx/vJv9dP/\
wAsNS4/4mVuMjNxySeSBhgwCsTMVcezF+7S96XTp/d/wntd9F/TXmU71WMR/ezj/iZaPytvqrE/8VEo\
5EVyCOQT8xPLEffEha5Ep32v7yYZhtcEQakSuYL3hQlwCwGCAUwpDEoAqyBqd6rGI/vZx/xMtH5W31V\
if+KiUciK5BHIJ+YnliPviQtciU77X95MMw2uCINSJXMF7woS4BYDBAKYUhiUAVZA1t/uZe9L4pfZ/u\
U/7u/9WBbr5GJr2gaJ4q8Na14Y8T6Tp3iPw14j0nUdB8Q+HNe0l9Y0HXtD1jw9NYato2taXqHmWuqaT\
dafcXFtc208UkM9vO6yo1qzRH+a79q/9l7w3+w74N8YfBH40eHvF3xl/wCCPXxi8VS3uk6hax6/4h+L\
v/BNP40eJDeR6D438E6rcreX938KJvEGv3CxSst7OzatdafqVtqepanf6f8AFf8Apnwfs2fMl+nlX23\
/AJBWfveds6fL0+783+o+SsPxtoGi+KPCXi7wz4m0yx8ReHPEWh6/oPiDQNd0e61fRdd0TV/Dd3Yarp\
Gs6RqEkkWp6ZdafcXFvcWs6Os0E7pIGt2aM/K8T8LYXiWlSXNHD5nQjUhRrTpKrBwqciq4bE0rJYjBY\
hJRxGHk1zWjUpyp16VKrT/c/A/xxzzwdzmcXCvm3Beb18LXzHLqOKng8RDE4OUpYHOcmx0FOeU8R5TO\
pUq5VmtGE3Tc6+CxlHGZVjMfgMT/ABEfFP4X/tGfsk/tGaX4l8NeIvDHxI+MXxJ8I6vN8OviTDpJ8Wf\
s7/8ABXH9nXxlZ6RJ4g8I+LtAOo3Fh4o/aC1Xw9qmip4j8Oz3tw/xHkvtO1bStRm+J83hfxL8Yf0G/w\
CCc/7Qfx78LeF9Z1L/AIJ1fCh/2sP2WfEDXmsa1+xt48+P/hr4b/GD9gP4w6vrsGp6t4P0T4ifEV2/4\
WL+z54kaTXL/wAL6hBaTy6lLY3Takuh+LNM8Ty+Jus/ak/Zd8L/ALD3hrxT8EfjZ4d8X/Gb/gjx8YvF\
Ml7pmo2ceu+IPjB/wTR+MXiW88rRfHXgfV7qO91C5+FE3iDX5kimdL9y+s3On6paapqmqXmn/FX8ZPE\
Gofsxapr2r33i34x/8E5P2hddm1rVhc/G/wCLngz/AIK+/D/4r/FKzh1gwaP4z+J/hf4K6Bp3h23+IV\
7ocVlLrV1ax3t/qeotdanr2t+IvEV5qGv6l/K2IWL4Fz+nOnj1k2IhKpKVCrj6GGxFCpOMVOeHxGJwu\
Lji8NiUoNYieBxFDHU4L6/SwucYFYit/uVlFTh76T3hTUpYnhep4k5XiqODpUc1wHCuY5vlGa4TDVJv\
D4fNspyfOsgrZDnOSyqV4zynD8TZRmnDGMxVRcLY3O/DviWeVYH+qAftdf8ABUjL4/4JBzf6yIn/AIz\
6+BPDC9mZQcaD180sBnLbgdpEu5jU0z9rn/gqOtnpYT/gkNPIFsNPWNz+3x8DkaRFtJhG4R9DMibkLk\
DdkYIGAJN38qg/4Y+y/wDyih/1keP+U6fT7ZLnGO3l7evzYxt/e7qhtP8Ahj7yrLd/w6j/AOPa03+Z/\
wAP0t+77PPu8zy/492zds+XONny769z/iK+c8lT/jKpatf8znIf5f8Asj9fw9D80X0GPDv2lKP/ABAm\
Oq/6N14pdJJf9JBefRr06r+rj/hrr/gqN5OP+HQkuz1/4b6+A23/AI8Nv/QA2/6nnp93/pj8leK/AH9\
rT/gp7B4G8TJZ/wDBJCW+if41ftQTTTf8N5fAy18q6uf2i/ibcalZtFNoRZhbXsktuZGJSX7OJSDG8Y\
X+bP8A4w/8n/nFFu/7zoZ/48f++f8AW/r/ANMq8r+Dn/DIv/CJa/5//Dqzf/wtT4/+X9t/4fhed5P/A\
Au3x59j8r+zv3f2TyNn2fzf3/keX9u/0nfW0fE/N5UamKfE0nOjKFNS/tfI3ZVVOTjzrhNQjzOknyyp\
TnPlvCpSUKkavxOP+g54eLxG4Vpf8QLjaeSZ/K3/ABDvxR1ccdw0k7f8TAOTtzvVTilzWcZNxcP6u/i\
9+3j/AMFOfhj8LPjL8StU/wCCV+m+B9P+H/gbxp451Pxn4k/bP+Fnjfw/4Ls/CfgyDXbrxNrngrw1BZ\
ar400bT7fTUvbrTNLvrK/1CGFrKzure8lgnj/Lr9n/AP4LL/8ABQP9oz9l79qTx94O/Zx0628YeHPHf\
i3xHcftG/BzQvFunfCT4XeH/hR8JPhF8RfGGieItJ+L+leJtI1HxTL4H0TVn3T6/BNJF430qKx0qTWk\
tY738rPiAv7LD+CfiAvht/8AgmnF4gbwz4iXQJPh+P8AgsofHcesNoMI0x/Ag+K6N4ZPiwXxQ6b/AMJ\
KraF9uEf9rg6dvFed/sa3Hwet/wBnf4u2/wAQvC/wi8Vai/xY1rQl8Pa9qf7S3hT9oCbwvrHhP4XaZq\
N38HvEHgG3l+GOlx2P9pa/eWl14ts9Vlg1rTNXFxpGs6RHoWkXX9V/QwxOceLPi/xJw4pPjDMcDwhmG\
NynBVoYHO8HLOqOOymlltXG0MJDhbCRw1GtXVTELNP7Sy+dGMqOMwdShVlUpfrGF+hl4OcPYDg7Nsx8\
AcLjMzo8WYT2FKrwnxZgXJQy/HVF7fAcQeKfEEcbl6qRSxjrZjgssVOUqWPweMpylKHs/i//AILnftt\
/ELw14l8K+OfE1l4+8FSXK23iPw/4r+E37OfiPwzqT6FqkWswNf6Dr/wskh1FYNStLS7g82Bylxbxyx\
hZ4wwK1fGn/BIHTtT/AGY9W/am/Za/aP8AFP7Q/wAM9J1vUrL45eHpfgZe/DDxt8J72XRND8Q6rJd6L\
f8AirXI/FWl6ZpmvWi67eaTqFxaaYJEvLW41PTYdW1HSyv1DgDJP2p+dYHNVwhwZlGFw2W4yph8VhqG\
Q+DWW4jDY2nCnGrTx2AxOBwuIw+IcFTlB1qEHVoOjVpudGVOb/r/AIH4Y+j3xDlmOXg94f8ACeCw2U4\
3E4XN8HU4b/sitg8zpTUXSxGWVsvwWOwtWWGWHmnjsNTqV6EqFai6mHqUpy/v/s9Nt5EuGl0jT3cahK\
mX0yxJCQ+IdRS2QZvWwo2hVGSMIF/dqAxsrpNlulxo2m5M9uW/4lljww1W5ZR/x9cfvy4xznG0lQBK0\
GnfZfJn29P7Svsf8gb/AKGDUfM/1fy/cx0/7a/u8VeH2bMmf+esWP8AkFfd+3Tbuv8A0x2/d+X+9+42\
V+c1KlZVKqVVpKa794/3v607H/JXp2/r7iCHSbISWe3RtNJEFoI/+JZYnKi2vxGcG6G7KGXklM7ckKQ\
FfPg0y1eG9STSdPaGK5SODdptkQkR8NWjlUP2okLiSZ/uL8zFtpb5G14/s2633dPKt9//ACCvveTdb/\
8AWcfe8v8A1nzf89Pn8qs20+zf8TPH+s+3R7v+QV97/hHdPx9z95/rNv3/AJvT97sq4TrfvX7XaK73+\
NdeYNLL+uxbm0myMl5u0bTQTBeCT/iWWIwptrASHAujtwgi5BfG7IDElUG0my3RZ0bTcie4K/8AEsse\
WOq2zMP+Prn9+EGOMZ2gsCZVnk+zbrjb08q42f8AIK+95Nrs/wBXx97zP9X83/PP5/NoP2bMeP8AnrL\
n/kFfd+3Q7en/AEx3fe+X+7+431lGpX5aX716W7/y/wCIFbXT+roz49Ntze3sR0jTzCi6ZIqHTLEos8\
mtat5hUfbeGaSONTheRGql8ASVZTSbLy4saNpuPI0gD/iWWJyq3LGA5+1DOXzzgbuhEQ+YwRfZf7Tvv\
732bSv+gN/q/wC1tZ/4F/qv+2f/AGyq8v2bamevlWGf+QV97zm8773P3cdfm/57/Jiqq1Kyk/3rX8Pa\
6+zTf839MNOxBbaTZBbfZo2mkCeIr/xLLE5YaUqqObpc/uMHB2/3sg/uq/Fz/gtVp9tB8HP2c2h0yxh\
B+Jf7ZGXisLSNjs/4Imf8FTZEy6XAPCxRyD5eGjWQfOBFX7VQ/ZsRbv8AnrHu/wCQV937CM/67/ptn7\
3y/wB79/mvxZ/4LX+R/wAKe/Zz/v8A/Cy/2yv+gd/0hQ/4Ko/8D/13+ftFeHxLOs+H89vVbTwlbv8A8\
+5/3jxuI7f6uZ9p/wAwWL/9R5n7PzaTZGS83aNpoJgvBJ/xLLEYU21gJDgXR24QRcgvjdkBiSqDaTZb\
os6NpuRPcFf+JZY8sdVtmYf8fXP78IMcYztBYEyrPJ9m3XG3p5Vxs/5BX3vJtdn+r4+95n+r+b/nn8/\
m0H7NmPH/AD1lz/yCvu/bodvT/pju+98v939xvr2o1K/LS/evS3f+X/Eeyra6f1dGfc6bbxI7QaRp6u\
2oaWjlNMsQdkviFklQ/wCmphW8ydWGWBBKnK4Z7MOk2Qks9ujaaSILQR/8SyxOVFtfiM4N0N2UMvJKZ\
25IUgK8F/8AZfJ+fp/aWj7f+QN/0MEf/Pb5fueX93/0X5VXo/s2633dPKt9/wDyCvveTdb/APWcfe8v\
/WfN/wA9Pn8qrc63spP2urlJdf5Ke/varyBWutCj/ZFh9lx/Y+m7PX+zbL/oDbfvefn/AI9+fu/7X3v\
3VN1bTbeOy1OWPSNPjmjW9kjdNMsUdJ00WTaUK3vysIwGGG4I3B8/u6t/uPI/2/8AuHf9A7/vv/Xf5+\
0VW1n7L/Zmq/3fs19/0Bv9X/ZMv/Af9b/2z/7a06dSs69FOq2m/O28f7wtCebSbIyXm7RtNBMF4JP+J\
ZYjCm2sBIcC6O3CCLkF8bsgMSVQbSbLdFnRtNyJ7gr/AMSyx5Y6rbMw/wCPrn9+EGOMZ2gsCZVnk+zb\
rjb08q42f8gr73k2uz/V8fe8z/V/N/zz+fzaD9mzHj/nrLn/AJBX3ft0O3p/0x3fe+X+7+431nGpX5a\
X716W7/y/4hq2un9XRAuk2W6XGjabkz25b/iWWPDDVbllH/H1x+/LjHOcbSVAErVtM023lt9Ill0jT3\
uH0/THZn0yxZ5HaxvSXcm9O9jumJJcEkZOCAJNAfZsyZ/56xY/5BX3ft027r/0x2/d+X+9+42VR0j7L\
9g0fH3P7N03P/IG/wCfKfd939318vr/AMC+byqr2lZ0637135l3/l/xeX5dgVrrQP7IsPsuP7H03Z6/\
2bZf9Abb97z8/wDHvz93/a+9+6rw39nfS7N/APi1pNJ092/4Xl+1mjltOsmKxp+0r8T42UE3B2qkSQg\
AF9oACh+ie9/uPI/2/wDuHf8AQO/77/13+ftFfPtp8BtU0GXxFD4S/aD+NPhPRNZ8U+PvGcXh3S9M/Z\
u1HTNK1bx/4q1LxzrsGm3fib4G6jftp58ReItYeFJr65mijlWKOU7HA5K1TFRxNCtDmrKFOrFqLSa5p\
UWn79SKt7jvre/LofH53TzHC8RZJnmDyevnWHwmCzHCVKeGqYSFaM8XXyutSnbGYnCU3TUcFVjPlqym\
pSp2g4uUo+meOvhr4P8Aih4U+IXw18eeFrHW/BfjzQ9c8C+KNF8uTSzqfhXxZ4f0rRtf0qLUdG1mG70\
wXFjqV1H51pc21xE10ZIJopcTR/HnwA/4J+fsifBz4WftC/szfD/4G6HpnwQ+IHxXn1jxZ4F1fWfF/j\
CLUtZ1T4W/A3SbnVINe8Z+MtQ1TSdSiTwt4bktJrK+tpLC90uLULGSG/3Xw97h+EfjU3mpBP2o/jqoX\
UIlcr4f/ZNzIfsWhNvfy/2dSobymdeQowgyNvnE8n4V+E/jSXX/AIkon7Tfxwtzb+PLWGaaHQP2Wmkv\
mbwL8OLhLq6E/wCz46JOLWdYAIVht/Ks4yIyTczS9uXV6+Exzz7C4Cph88yvD0ZYbG0/YQxeGccThKk\
Z0MRHEKtRamlJOlNSU7Ssmm13PxS8Rcmp8O5Rk+W8T5PlCzmnmX1TDZpltDDyzDC5fjvquNVCjn0aX1\
3DaSoYqUVVoqP7upGXKn/MP+13+zJ+0d/wTH8R/EnSvhh4r1y9/Zq/aO8P6v8ADaTxVLo2g6tZa7oGq\
rqwm+HPxJ06806ey0L4mWemPrq6drFnDZ3F9p8+o3mg3NgZde0vTiv6Df22fAVp4R/ZG/aR8X/Fb4of\
tKfHHwB4Q+EvjHxbr3wj8L+AP2bfEXifx/H4YtL/AF3T/Dvhqz8M/sxXV/p3iGbUtP002Wq2kaNod1H\
FrL3NlbWAvICv9FfD39pNwDwRkFPDeM3Ceaz48xfJHEZnkuXZfW/telhqVOjQxWPbx2ElDGU6aVGUV7\
Wk4wU6PsYT9hT/ANtPo4ftN8BQ4NrvxV+j7xJmniJCdChmGdZCuAqTzuGGoQpYTF5lHH8XZRV+vU6CV\
CapxxGH5YKdF4aFT6rR/RPT5pDFcE3kDE6ld/MLu2YHZ4i1Jlww08A7Cdx4G0Hc28HaLiyvmT/SoRma\
Ak/aoBuI1K4cMP8AQvmAYlyRgBXDkMpEa5VnbJKlw7JqCn+0JUwmqeIYxi38Q6j5ZKqq5ZsAMxG52yw\
MkhYVZWyiDS8alzPbsf8AiceIuCuq3MoHDd3Yrzg/LwC+Y1/zmqRpe0q3Uk+dfZj3j/f/AKsf423env\
W+8uRSuHtSLqFdsNqATdQKIwsF6ArE2R2FQxBBDFTKASxZWTNtZXK6ipuoWAvEAjF1AzIP+EasF2tGL\
IMh2krguxywXO4h1mhsolksyBqRKQWiqP7Y8RfMEtr9VPysTyJGPyhh8nylhuZM+C1jeG9iZdQVIblI\
0ddV19C6nw1aAs7DaJWxK53F34ULuEahkuEaV6vuO3LHXlhp7y/v9A6LX+tDcllcvdE3ULboboEi6gY\
SBoLIFVIshvLBQAAFLGIgFSrM40r5j/0qE4mnIP2qA7SdSt3LH/QvlBYBwTkFULgKoMbU5rKJpLwkak\
C8F4rD+2PEXyh7awVj8zA8CNT8wUfP8xUbWcayiLRcalxPcMP+Jx4i5LarbSkct2dQvGT83ID4jbKMa\
PLS92XT7MNPd/x/Ieuut/v8gimk/tG+H2yDHkaU237XbZz/AGzrL+Zt/s/O3d8+7O3Hz7NvyVcSVwkY\
+1QjEOmDBuoAQEnYqpBsjgoeWBJKA5cyD5ayo7ZDe3sWzUNirpkwYap4hDl31rVnKNIFy67o1AUuSpL\
FUEjMhspZRCOIY1IgQaQoP9seIuRDcsyHhiPmJxwSP+eZkPy1dSNLmd4yjrT+zH+Wnr8fzEr/AM1vvL\
lvK4EGLqFMTRkBrqBNpGmqgY7rJtoC/Jk7gGGwgt+8r8Wf+C18jf8ACnP2c1+0RY/4WX+2V8n2iHd/y\
hM/4Kox/c+y5+7+7+997939/wDe1+zVtZRKtvgak22eJh/xOPEXJGlLEB8jN/AN3GT6Ap+8r8XP+C1V\
tHD8HP2cwgvjn4l/tkcy6lrU6/J/wRM/4KmgYWYsg4jVjz8yllbMDM58PiSNL+wM9tF3+p1teWP/AD7\
np8b2PG4jv/q5n2v/ADBYv/1HmftfLK5e6JuoW3Q3QJF1AwkDQWQKqRZDeWCgAAKWMRAKlWZxpXzH/p\
UJxNOQftUB2k6lbuWP+hfKCwDgnIKoXAVQY2pzWUTSXhI1IF4LxWH9seIvlD21grH5mB4Ean5go+f5i\
o2s41lEWi41Lie4Yf8AE48RcltVtpSOW7OoXjJ+bkB8Rt7MY0eWl7sun2Yae7/j+R7Wuut/v8gvZpFi\
JF5AhOpaPlmu7ZA3/FRK3DNp7BuWLcAcSBujKqXIpXD2pF1Cu2G1AJuoFEYWC9AVibI7CoYgghiplAJ\
YsrJlXNskKO6JqDl9Q0tCH1TxDIAJPELbiF2vhh5zhWIVlZAylZFISzDZRLJZkDUiUgtFUf2x4i+YJb\
X6qflYnkSMflDD5PlLDcyXKNL2UvcbXNL7MNfcp6fH0BXutb7f8MT+Y32bb9oix/c+0Q7v+QV5f3Psu\
fu/u/vfe/d/f/e1BrM0n9naqftkGfIvm3fa7bGf7HlTzN39n427fk3Y27vk2bvnqD7BD9l2f8TLH97+\
2PEH/QG8n/npt+5833v/ACH+9purWyR2WpyqmoF0W9mCvqniGRC66LIgR45FIkXaMlWQkjgoY/nqqca\
Xt6Voybvtyx7w0+P+rC6bmrLK5e6JuoW3Q3QJF1AwkDQWQKqRZDeWCgAAKWMRAKlWZxpXzH/pUJxNOQ\
ftUB2k6lbuWP8AoXygsA4JyCqFwFUGNqc1lE0l4SNSBeC8Vh/bHiL5Q9tYKx+ZgeBGp+YKPn+YqNrON\
ZRFouNS4nuGH/E48RcltVtpSOW7OoXjJ+bkB8RtlGNHlpe7Lp9mGnu/4/kPXXW/3+RcWV8yf6VCMzQE\
n7VANxGpXDhh/oXzAMS5IwArhyGUiNaekzSGy0ZvtkBI03TP3gu7YqMWNyBmQaeAMB2B+U480A5LKUF\
sog0vGpcz27H/AInHiLgrqtzKBw3d2K84Py8AvmNa2mWyS2+kTsmoK7afpjlE1TxDEmTY3vCRIq+Wv7\
18KqbQEwo2hilctL2Vf3W1dfZj/Lt8f9WBXutb/f5Gh5jfZtv2iLH9z7RDu/5BXl/c+y5+7+7+99793\
9/97Ussrl7om6hbdDdAkXUDCQNBZAqpFkN5YKAAApYxEAqVZnzPsEP2XZ/xMsf3v7Y8Qf8AQG8n/npt\
+5833v8AyH+9qeayiaS8JGpAvBeKw/tjxF8oe2sFY/MwPAjU/MFHz/MVG1nOWjzx0ls/sx7x/v8A9WF\
r/N+YQzSNfamTeQORqUOGW7tnC/6F4ebll09QvKhuQeIy3RWV+M8Hyv8A8JH8U/8ASYv+Si2hz9pgwC\
fh/wDC1y+fsfCllDg4wVjLhQqmNuqS2SW+v9yagvlahCiBdU8QoWH2fw9Pl2Ko0rb/AJdxDttYKD8sa\
NxPg+yh/wCEk+KXGpcfEa2Yf8TfxDyW8BfCyUqfnycOoXu3zYKh9sbejhI0vq2Y3g1/stL7MP8An/hN\
fj6niZrf6/w1rf8A26p8v+E7H6nG/tWSOf2Xf2lx9piO74EfFvIFxCS+PBvip8qBaAvhmL8FcK4c5Vh\
GpXKfto694R8F/sk/tL654x8SWPhLRJPg9460Iaz4m8YX+haV/bviyx1nwx4T0UX+r3kMDarqnizXdH\
0vT7ZnWa91DVbWyto5ru4jtyV/EH0ncNKvn/DXsKFSryYWtdRp81r1Y2vyydr2aV97H9feAeb5VleS5\
7/aebYfLfb4qnyKvXhR5+WlHm5faSjzcvNFSte3Mr7o+nNPVvKuP3s5/wCJld8m31UE58RakBkPckjB\
5GT8xOItr5NXFU5k/eTf66D/AJYalz/xMrgZOLjgg8gHLFiVUiYM5p6ekYiuMRQAf2ld8DSLmMc+ItS\
DYQtlcjg/89R+7XkVcVEzJ+7h/wBdAB/xLJzgHUrhSAN3yDaACp5ZQIR8yE1/ZdV/vK3vS/iLp5x/u/\
1qfy520X3/APBCJTvtf3kwzDa4Ig1IlcwXvChLgFgMEAphSGJQBVkDZtqp26ifMmI+2J8pg1IKP+Kas\
DhXe4MbDHGVULgliPLDKdKJEL2uY4TmG1Jzpk7gkwXpJZQ378kgEsOHKhhxG1ZtqiBdRIjhBN4hLDTJ\
0Yn/AIRqwOWuC22U7gDuHAIEv3VNXB/xvel8Efs/31/dDovX/I0pVO+6/eTHEN1kmDUgWxBZcMHuCVB\
yAS+VAUFwVaMKMpzH+8m/10//ACw1Lj/iZW4yM3HJJ5IGGDAKxMxVwSoge6xHCMQ3RGNMnQAiCyIKqW\
/cEEkhjwhYseJFoZEzH+7h/wBdOD/xLJxkDUrdQCN3zjaSAo5VSYT8zg1lF+7S96XTp/d/wj76L+mvM\
pxK39o3372f/UaUMfZ9Vxn+2dZG7P2nbuzzjHmbvl3eb81XEU7I/wB5MP3OmcCDUiBmdsAFbjBC9VIw\
rHiEI2TVOJI/7Rvj5UGfI0oZ/si5zj+2dZG3zN2Nu3jy/vY/dfe5q4iJsj/dw/6nTDzpk7Elp2DEsG+\
ckcMw4mHypgirqv3n70v+XfT+7T/uiXovv/4IW6nEH7yYfvo/uwak2P8AiWqcjyrgbjjjC4Yr8wIhwl\
fiz/wWvB/4U5+zmfMl/wCSl/tlceVfbf8AlCZ/wVRP3vO2dPl6fd+b/UfJX7TW6IRBmOE5mjB3aZPLk\
f2arEEq37wbudo5Lfvh8pxX4s/8Fr1X/hTn7OZ2RZ/4WX+2Vz9gm3f8oTP+CqLf67dj73P+9+/+5xXh\
8SP/AIQM996X+6V+n/Tuf908biP/AJJzPv8AsCxf/qPM/aaVTvuv3kxxDdZJg1IFsQWXDB7glQcgEvl\
QFBcFWjC/mf8As2f8FWP2cf2ofA2oeP8AwP4G/ay0/SdJ8Y6n4QnhP7KPx3+JpbULK38L63LN/b37PG\
geNtFtC1t4jsv9DudVttWjMYmuLCOC50+8uv0wlRA91iOEYhuiMaZOgBEFkQVUt+4IJJDHhCxY8SLX5\
+f8E2Pjd8Kvj18AvGniv4TeJbfxZ4ftP2sf2xftN+vhLxRoIj/4Tz9qDx/8Z/CYNp4k0uznmF38Mvin\
4F1IBYybddf/ALOufJ1GG7tbfizPGZhHPOH8uwOb0MAsZh8bVlSr4f20sQ6H1OMVStXw84+yVac58vO\
mmuZRSuf0BwNkXClbwv8AEziziTgTN+KamQZnwzg6OPyzMv7PoZRDMqef1KzxzqZTmuGq/X55dh6GG9\
t9XcJwqeynUlJwXE/Cj/gqp+zn8bvGvxu+H/hjwR+1hZ6v8CPHujeEPFU5/ZS+PPjP7bqB8beKdJ8z+\
wfhFofiLW/ArfaPB+pMLLxnpfhnVmaf7OmnNfWmrQWXpPwQ/wCChvwT+PX7Vfj39kbwX4Y+OOj/ABF+\
GXw4sfiVrmr/ABH+FXiP4X6HcaFJB4HUWdn4b8dapp/i/T9V3fEzQ/LTU/DGlwXMFvcXlnNLYPZ3Gof\
W/iXx34B8P+JPB/gXxB4w8F6J42+IepXP/Cv/AAdrV7YWXinxx/wiWowav4q/4Q3w5d38d54i/szR5b\
e51D7HDP8AYrWSN7ny0XefwW8YfG/9tebT/gN+2nrPxp/Y30PV/gL+0p8UP2Ff2oPDHhj4U67N8Jvg3\
4M+Jfx60P4NeOviL8UvFfj39pK21fxBpuneLPhd8BvFemWFjb+C9X/s7xraX2qXH/COrqDTfO5xnPEP\
D2HwKxWbwzqWHxFati1hcthSn9TpvD+3jOVXMXCjKhQxlGveMKlWdKhObhGEpzj+zeH/AIceFPiziuJ\
55HwHjPDrD5vl+Ey7IJ51xZicZRjxDjMLjlluIw9LA8HRxGZ081zTh/Mcr5K2IwuBwuPzKhhlXqYilh\
8NV/odwfs2fMl+nlX23/kFZ+952zp8vT7vzf6j5Kg1lW/s7Vf3s/8AqL4Z+z6rnP8AY8p3Y+07t2OMZ\
8zHzbvK+WvjC88UftS/DP4m/s66D8SPiP8As9fEHwb8Zvit4k+GWs2Hgj9mr4mfDHxTpP8AZv7NPxv+\
Men63pnirXf2pPFlmcaz8J7G1mtptIfzYdYluEuIGjQt9n6ykf8AZ2qjyoMeRfDH9kXOMf2PKdvl7s7\
d3Pl/e3fvfu8V99lmYLHV6ieHrYOrg6qpThVVJyUnChWTTozrQacKsGrSve6aVj+WuJ+GJcNPJZwznB\
5/gc/wbxuGxOC+uRpSpRxmMwE4yhj8JgcRCpDEYGvGSlh+Vx5ZwnJS0uSqd91+8mOIbrJMGpAtiCy4Y\
PcEqDkAl8qAoLgq0YUZTmP95N/rp/8AlhqXH/EytxkZuOSTyQMMGAViZirglRA91iOEYhuiMaZOgBEF\
kQVUt+4IJJDHhCxY8SLQyJmP93D/AK6cH/iWTjIGpW6gEbvnG0kBRyqkwn5nBrqi/dpe9Lp0/u/4T5j\
vov6a8wVTmT95N/roP+WGpc/8TK4GTi44IPIByxYlVImDOaekq32LRh5s5P8AZumfMbfVQw/0G56K1z\
vPQ4wedxK4CyhriomZP3cP+ugA/wCJZOcA6lcKQBu+QbQAVPLKBCPmQmqekpH9i0YeVBj+zdM4GkXKr\
zY3OcwFstyFz/e2gjiJqtP91X96XxR6f3H/AHQW8dF/XzJ8H7NnzJfp5V9t/wCQVn73nbOny9Pu/N/q\
PkqWVTvuv3kxxDdZJg1IFsQWXDB7glQcgEvlQFBcFWjCxbV+zZ2RZ9fsE27/AJBW7/Xbsfe5/wB79/8\
Ac4qWVED3WI4RiG6Ixpk6AEQWRBVS37ggkkMeELFjxItTf34+9LZ9POP93+tRfJff/wAEpwqwvtT/AH\
s5/wCJlDy1vqqkf6F4eHAluSTyQflI5UD75jK8Z4PU/wDCR/FP95L/AMlFtP8AljqOf+Sf/C0Zx5+dx\
JBIHzBlCsTKUYdnCkYvtTxFAAdShyF0i5hB/wBC8PDlGbMnBI47MU6yLXGeD0T/AISP4p/u4v8Akoto\
P+QbPjA+H/wtUDbu5XaSAnVVJiPzODXpYV/7NmPvS/3Wl9n/AKf4T+6eJmv+/wDDX/YdU/8AVdj/AMP\
6ufi7/wAHNFzNZf8ABEH9uO5hungkRP2cUEr207KFn/bC+CNu+ftrPFGxSR9rSKzK75jK3CmSiv2U+M\
fwU+Ef7Q/wz8Z/Bj45/DfwZ8V/hT48tbLTPF3gLxz4Si8QeG9btrXxDHqunSXGnXyMsF/Z6xp2mX1hc\
x7LuxvtKtLmxmt76zhnjK8x4+lhLxfCWX8QVJyu62Mq1qVSCShanFUsLXTgnzTTbi1KclY+3yzMsVha\
EqFPiLH5RR53NUsJd05SkoxlUkvrdBKbUYRbUW3GEU3okdxZ6e7JcbZdQhA1CVfLS38PYBHiHUY5HO6\
ybDTbSGwdu4kEJHtAsrpsu6X/AEvUjie3AH2fw78oOq3KlOdP43IBFxx+7wSEwxg077L5M+3p/aV9j/\
kDf9DBqPmf6v5fuY6f9tf3eKvD7NmTP/PWLH/IK+79um3df+mO37vy/wB79xsrepOoqlVe7pNfYj3j/\
X9O/h6dvx/4BBDpspks83epODBaFl+z+HT5pNtfln+bT8HcVVvmwT5HzAEKDnwafIYb0rPqETrcoHuF\
g0DNw3/CNWkgmcmxJ3AlDwqcQA7TJktrx/Zt1vu6eVb7/wDkFfe8m63/AOs4+95f+s+b/np8/lVm2n2\
b/iZ4/wBZ9uj3f8gr73/CO6fj7n7z/Wbfv/N6fvdlXCdT967x0ivsL+dfL8A6L+uxbm02USXmLvUkAg\
vCq/Z/Do8oi2sCr/Lp+BtLM3y5I8/5QSWAG02XdF/pepDM9wCPs/h35gNVtlCcafztQmLnj95gEplhP\
J9m3XG3p5Vxs/5BX3vJtdn+r4+95n+r+b/nn8/m0H7NmPH/AD1lz/yCvu/bodvT/pju+98v939xvrKM\
6nLS1hpb7Ef5f67gra/11Rnx6e5vb1fN1AOF0zM4t/D290bWtWQWzZssBVVGQYUDMjBmaPaVsppsvlx\
f6XqTEwaQS32fw78xa5YO/On5/ej5eeTj94FHNQRfZf7Tvv732bSv+gN/q/7W1n/gX+q/7Z/9sqvL9m\
2pnr5Vhn/kFfe85vO+9z93HX5v+e/yYqqs6ik9Yv8Ah/Yj/LT73/ry0DTsQW2mylbfN3qUmZ4gT9n8O\
neDpSsU+fTxnL/vecDnJO/5a/Fz/gtVZSR/Bz9nNnnvp/8Ai5f7ZHzSw6KFG3/giZ/wVNmODDZo/wAx\
RmP+zKzLifaV/aqH7NiLd/z1j3f8gr7v2EZ/13/TbP3vl/vfv81+LP8AwWv8j/hT37Of9/8A4WX+2V/\
0Dv8ApCh/wVR/4H/rv8/aK8PiWdR8P57dxt9UrfYS/wCXczxuI7f6uZ9/2BYv/wBR5n7PzabKJLzF3q\
SAQXhVfs/h0eURbWBV/l0/A2lmb5ckef8AKCSwHxT+wT4u8E/ET4KeLtY+H3jzQ/GukQ/tYfttrPqXg\
3XPA3ibTV/t/wDbJ+LfjbQPNvtGW4iRr7wR4t8L6tabnC3Ol+LdPv7YNYXtvM/27J9m3XG3p5Vxs/5B\
X3vJtdn+r4+95n+r+b/nn8/m18pN+wf+wrmP/jDT9lLAklB/4x3+BvC/b4SoGPB+P9UX+98vPy/ud9L\
HUs3eY5Vj8vhha0MNRxNKrTrOVJv2zw04ShOFKsvdeHakpQd1JWaad/2DhXNuC1wdxZwxxViM0y/FZt\
j8mx2DxOX4XCY2nD+zqOcUMRSxOGxONy+UvbRzOnKjUpYlezlSnzwmpRS3PjZ+yN+z5+0H4n+G3jP45\
fC3SPi1q/wgvvEMfgCx8bWel614W0kfEW+07RfFZ1XwPc40Txd5tnoujG3GsWGoLY3OjQ3VitvOizN+\
fvwp+BPw0+GP7I3/AAVM+A+qxaH8A/BWk/FL9r9fiD468D2E/jjwrpvgb4zfAXR/jJ4W8fab8MrXw7p\
j6CfDH7P/AMUvh1oVx4S0AJZy3PwmmfTblptRWQ+1eLP+CVn7G9/8V/h/8YPCegfEP4LX/wAP/E/iPX\
bLwV+z/wDFbxD8Efh1qOufELw/4Y+Gmt61beGvh/q9gfh1qzeFfCnh9bm58D3PhabW5LJf+ElfXLXyo\
R8ka94c8EfB/wCLH7bv7PfiL/goD8WP2HB8Q08B/FD4Ra38Q/jd+zv4o0/x34Z+KP7Onh/4Nv4+sfiP\
+0dNrfxS1rxZovxU+B/jqx1Kzt/Gnhq60nStL8NtoF7pUl5ZajH8Tn/1nCVpZrmPDOX4Svja2Lwbr0a\
1CpPFQrZWuWeIqV6GXKkr4enh+eWLp1oxpKjTm6daJ/UHhZiMtz7IlwPwl408TZ9lnD2ByXPY5bmOUY\
7CYfI8Tl3GdD22GyrB5XmfF316Shm+MzdYelkGJwNStjqmZYzDwxWX1eb1L9m34l+K/jr+z3/wSX+Ln\
jb4vX3xp8aeOf2g/iLqniz4gL8PvCfw4CeKYv2N/wBumz8QeEE8L6XoVrbq3hjWLK98NnUbe2S21v8A\
4RM65bpjUI8fr9q2nullqbNLqEiKt7mB7fw8EkQaLI5tn8uyUhSw3nayjByGEnFfi3+zxqvwJ+Hnhz/\
gmT+yx4E/bP8AhT+1143+EX7QfxOMviHwh8QPAGu+J5fA6/sg/tr3GgCTwhpHxE8RX2g+FNB03xN4W8\
O2Y+2yWdtbadp9tALQyW9lF+02s/Zf7M1X+79mvv8AoDf6v+yZf+A/63/tn/21r3fD3EYmtl0VicRTx\
ONpPBU8RJVIYlrEQyrK411KvGtiPaTVRS55+3qylK8nVqNucvy36UuBy/A+IND+xMqq5Rw1jv8AWHE5\
RSqZfPKU8oxHHfF1TLalHLp5flP1PDzwbpOjh45Zl8KMLU4YLCqHsKc82myiS8xd6kgEF4VX7P4dHlE\
W1gVf5dPwNpZm+XJHn/KCSwA2my7ov9L1IZnuAR9n8O/MBqtsoTjT+dqExc8fvMAlMsJ5Ps26429PKu\
Nn/IK+95Nrs/1fH3vM/wBX83/PP5/NoP2bMeP+esuf+QV937dDt6f9Md33vl/u/uN9faRnU5aWsNLfY\
j/L/Xc/mpW1/rqiBdNl3S/6XqRxPbgD7P4d+UHVblSnOn8bkAi44/d4JCYY1tM092t9IKy6hCj6fpjC\
2S38PFFDWN62xN9k2V4TG5yxFv8AMSwXdoD7NmTP/PWLH/IK+79um3df+mO37vy/3v3GyqOkfZfsGj4\
+5/Zum5/5A3/PlPu+7+76+X1/4F83lVXPUdOtrG/MvsL+X/gev43Fa6D+zpvsuftupZ/56eR4f/6A2/\
r/AGdu+/8Avenv/rPlqebTZRJeYu9SQCC8Kr9n8OjyiLawKv8ALp+BtLM3y5I8/wCUElgHfuPI/wBv/\
uHf9A7/AL7/ANd/n7RUsn2bdcbenlXGz/kFfe8m12f6vj73mf6v5v8Ann8/m0vaVOePwbP7Ee8f6/rU\
07Gemnv9uv1WXUINuoQq4W38PZnJt/Dx3uBZMu7ZJ5XG1drjI5keuJ8H6dN/wknxSH2vUh/xca2BH2f\
w98wHgL4WKEP/ABL8fKjGP+7+9wMoWYdxb/ZftuqbOn9pQ7v+QN/z4aB/zx+X7nmfe/8ARfm1x3g/7P\
8A8JH8U/T/AIWHZ5/5Bn3f+Fd/C/b7f6rf1+T+7+58yvSwk6iw2Y6x/wB1pfYX/P8Awnf/AIbyPEzW3\
17hryxtT/1XY87hdNl3S/6XqRxPbgD7P4d+UHVblSnOn8bkAi44/d4JCYYlTj7NmTP/AD1ix/yCvu/b\
pt3X/pjt+78v979xsorxqs6je8Fr/Iu0PT+vvPcjb+n5og0+aQxXBN5AxOpXfzC7tmB2eItSZcMNPAO\
wnceBtB3NvB2i4sr5k/0qEZmgJP2qAbiNSuHDD/QvmAYlyRgBXDkMpEa5VnJehLjyrNWT+0JTmXU9aR\
w58Q6iZ1IOksSoYsIyTliNyKshKiysuo7pf9Bg/wBfb4xqus5x/atzndjRvveXtxn5vM3bf3u6tqlJu\
pVfJHWa+1DvH+9/VvIV3p735lyKVw9qRdQrthtQCbqBRGFgvQFYmyOwqGIIIYqZQCWLKyZtrK5XUVN1\
CwF4gEYuoGZB/wAI1YLtaMWQZDtJXBdjlgudxDrNDLqPmWebGDHkWm7bqus5z9mv93l7NGzt3bNuz5c\
b9ny76z4JL8Q3uyziMhuUMwk1PV1hST/hGrQBYSdJKSRYERJAUYZ12+WpZrhT1q/u1dxjren/ADLrza\
WDotf60NyWVy90TdQtuhugSLqBhIGgsgVUiyG8sFAAAUsYiAVKszjSvmP/AEqE4mnIP2qA7SdSt3LH/\
QvlBYBwTkFULgKoMbU5pdR8y8xYwY8i827tV1nOfs1ht8zfo2du7fu3/LjZv+XZXx3+zf4h/bO1P4s/\
tO2v7RfgjRtD+Flr8SPP/ZuvrSTw9YSz+C4vGnjXww2mWl34T8feIL/xBpUvgXwn8LPE0174i0vw3rM\
fiX4q+ItKjsG0vS9Iis/NrYhYfE5XhHgqtZ4+U4qpThCdKj7OjKo5YipzWpRlyqnTbu51JRilu19JlP\
Dss1yTivPP7cy7Lo8LUcLWeFxeLjRx2YPFY2hg1RyrDOMp4ytQVV4vFRjyRoYOhWrTnzKnTqfYkU0n9\
o3w+2QY8jSm2/a7bOf7Z1l/M2/2fnbu+fdnbj59m35KuJK4SMfaoRiHTBg3UAICTsVUg2RwUPLAklAc\
uZB8tZUcl79tvSLNTKV0wMp1PWhEIhrWreWyyf2ThpypkBBUMrIpDNIxC2Ul1Hy4s2MGfI0jONV1nGf\
tLeZt26Njbt/1ePl3f6r5s16FSleTtTitaf2qa+zT/vfP8T5tX/mt95ct5XAgxdQpiaMgNdQJtI01UD\
HdZNtAX5MncAw2EFv3lfiz/wAFr5G/4U5+zmv2iLH/AAsv9sr5PtEO7/lCZ/wVRj+59lz939397737v\
7/72v2atpdR22+6xg/18Wdmq6zjH9lLnZ5ejfe8zpt+by+n7qvxQ/4LWvqDfCv9mvzrZo4x8QP21Qwg\
vdUntGc/8EUv+Cnw3TFtPjjSdU+0GIYYvHvXdHBuavE4io3yHPVyRjbB13e8HtSm7aSv0t5bnjcSP/j\
HM+1/5gsX/wCo8z6P+I3/AAVC+GPgT9pL4k/suw/Cr4n+LPiR4E8V+BPACTW/xR/Yq+HOk/ETxd8Ufh\
78P/Hvhvw98KLL49/tS+Dta+ImrGw8c+HrC4tdP0c3MepyC2SNknsrm+8r+HH/AAWU+F/xUMMXh39mz\
9pLQ9Wl+NHif9n2w8LfFTxz+wn8DvHOr/G7wpe+CpfE/wAMdA8BfGn9sTw/rXiDxfZXfjvwbb3FrZWF\
yUvNehtMC4EtsPza8Y6d8KPFX/Bb79pzw7+1BoH7P+nfCDR/jL+yf8RPhN44+IPj6x8K/FpP2o/Cn7N\
fwKTwJ4B8EjUvE9tqXiT4eapDfadL4i06PQL/AEu6vNO0CPVru3xpySffn/BUvwx8KfD9l+zff/DP4U\
/sq+IP25fCPxw8LeOP2O/h98VvHtr8L5vFPjLTPG3hqxuodLkh8eeBpvEpjuZPD89rpDa0YdT1zR9It\
msNSnVLN/g6Gb8SYrBcQ5pHMcNSw+R47G0I0KdOE6k6eGxEqUIr91UqKvKlBwpxpxxP1nESjTiqTjKB\
/cOG4G8J8vzPwk4Ox3BWNzLOfEbJMox1XNZ490MFhMTmGCdadaf/AApYfD1MDRrVKE8yrYmvk6ybB0M\
XWq/XIOnVh+p3wf8Ai5o3x2+CXwj+OXha31jQfDXxm8BfCn4reHtH8WSaHZeJ9K0L4iW2j+MdI0vxHb\
6NPqNlBr9vYa1BHeR2d7eWqTh/s93cQGOSvW4pXD2pF1Cu2G1AJuoFEYWC9AVibI7CoYgghiplAJYsr\
J8S/wDBPeS8/wCHff7DYktF8sfslfsoeW8Oo6uXZh8NvBZiDxwaXhFYiIN8zBCzld7hg32dDLqPmWeb\
GDHkWm7bqus5z9mv93l7NGzt3bNuz5cb9ny76/TMDKeJyzCYipSj7SvTjUlZwUW50aUmleW13om7pbn\
8q8T5bh8m4n4hyfCTlPCZTj8XhqTm7zdOhiKlKHO1GKcuWCcmoxTd2ktifzG+zbftEWP7n2iHd/yCvL\
+59lz939397737v7/72oNZmk/s7VT9sgz5F8277XbYz/Y8qeZu/s/G3b8m7G3d8mzd89Qebqf2X/jxt\
t3/AGFdW2f8gb/sDbf9b/5D/wCmVN1aS9NlqYks1SIreiRk1PWpJViOiybmSNtJUvOGyQCysVGCwj5r\
tp0rV6TdOLSe3NTfWHTm/qx4PTc1ZZXL3RN1C26G6BIuoGEgaCyBVSLIbywUAABSxiIBUqzONK+Y/wD\
SoTiacg/aoDtJ1K3csf8AQvlBYBwTkFULgKoMbfHk/wAbf2kPFXxL+O3g74S/An4L+IPDvwX8daX8N7\
/xH8Rv2mfid8Pda1zXNY+Cnwc+MVxd23hjw7+yf4phttIg0/4r6ZZK82rNJPLpk0ksMERtw2w3jH9uH\
MX/ABjp+yz/AK6f/m9D43c/8TO3OBn9grhscHHzFiCwEoVT87HPculeMKGKq+wqVKUpQwGMnDnoylSq\
KM4YeUJqNSEo80JSjK14txab/RJ+F/FdKnhKmJxGS4N4/C4PG04YjibhvD1vq+Pw1DG4WdShXzanXoy\
q4avRq+yrU6damp8tWnCalFfVayvmT/SoRmaAk/aoBuI1K4cMP9C+YBiXJGAFcOQykRrT0maQ2WjN9s\
gJGm6Z+8F3bFRixuQMyDTwBgOwPynHmgHJZSnx/b/tUeKbP9kf42ftM+JfhZo1hr/wS0/9qK48QfDnQ\
/if4h1vR9V1n9lr4k/F7wRrWnaR8QNR+F+mzNpmr3nwunmtL250CCa2TWFL2Mk8MiyeZfBb/gn58J28\
I+D/ABR+1Z8P/CP7Wn7RXiHwN4Si+K3xS+Pt1qPxrtz4h87xh4t1jw98IvD/AI/8FjS/hL8KrLxV418\
Qw6Lo3hnQ9AthpcFkNQtrq8tpLkv+1auL+r08mwEMfDF0KeLlOtVeGp06FWFqF70atR1q75nGjKnBwh\
RrOrKnKNOFXup+HuByPCcQ4vxEz2twzUyTNa2R0sNl+Fwmc4nFZlgnfM4xtmuBwkcFlsJYdVsbTxddV\
6+OwUMFSxNGWKxOD/RTzG+zbftEWP7n2iHd/wAgry/ufZc/d/d/e+9+7+/+9qWWVy90TdQtuhugSLqB\
hIGgsgVUiyG8sFAAAUsYiAVKsz/mh+y3fTfs5ftDfEn9gKLx7e+LfBPhz4I+Af2jf2Y/CXi6bxfq/jL\
4afCHXvEnj/4a+PPhFJ8Sp7O4i8Y/D3wn4q8P+A18Kf2wINestE8fJojXeuaboSXVn+kc0uo+ZeYsYM\
eRebd2q6znP2aw2+Zv0bO3dv3b/lxs3/LsrrynGPM8NGtLDww2Jozq0a9JVqNT2VejUVOpDnjJc0W0p\
0pSjTnOjKnUlTpuXJHwOO+EZcF59/ZtHMJZvk+YYXB5jluOlha+D+vZbmGHp4rCYh4esm6VaMKn1fGU\
qVXFUMPj6GKw1DGYunRjiKhDNI19qZN5A5GpQ4Zbu2cL/oXh5uWXT1C8qG5B4jLdFZX4zwfK/wDwkfx\
T/wBJi/5KLaHP2mDAJ+H/AMLXL5+x8KWUODjBWMuFCqY26pJL0X1/5dmpJ1CEyiXU9aUo/wBn8PALCX\
0ktIvkgHICnzGC7dyxs3E+D5dR/wCEk+KX+gwf8lGts/8AE11fOP8AhAvhZtx/xJsl/L3Z/i37d37zZ\
X0mEpXw2Y2ppf7LS+1TX/L/AAmvxfifmOav/b+Gtf8AmOqf+q7H6npayvmT/SoRmaAk/aoBuI1K4cMP\
9C+YBiXJGAFcOQykRqVTWXUd0v8AoMH+vt8Y1XWc4/tW5zuxo33vL24z83mbtv73dRXjVaWutOL1/mp\
9of3vke7F/wB78+6DT1byrj97Of8AiZXfJt9VBOfEWpAZD3JIweRk/MTiLa+TVxVOZP3k3+ug/wCWGp\
c/8TK4GTi44IPIByxYlVImDOaenwyCK4Bs4FI1K7+UWlsoG/xFqSrhRqBA3kbTydwG1tgG43FifMn+i\
wnE0AI+ywHaTqVwgUf6b8oLAoQMgqgQlVAkbWq17St+8/5eLt3j5f1cmz0938wiU77X95MMw2uCINSJ\
XMF7woS4BYDBAKYUhiUAVZA2baqduonzJiPtifKYNSCj/imrA4V3uDGwxxlVC4JYjywynSiicvagWsL\
bobUgG1gYSBoL0hmBvRvLBSSSVLGIEhSqq+baxOF1FjawqDeIRILWBWcf8I1YNuaQXpZztBbJRTlQ2N\
wCNcHH99+9+xHS8f515dQ6LTr/AJGlKp33X7yY4huskwakC2ILLhg9wSoOQCXyoCguCrRhRlOY/wB5N\
/rp/wDlhqXH/EytxkZuOSTyQMMGAViZirglicPdA2sK7YbokC1gURhYLIllAvTsKhgQQWKmUkBizKg0\
T5j/ANFhGZpwB9lgG4jUrdCp/wBN+YBiEAOAFcoCykyLlFrlpfve38uvu+g++lv+HRTiVv7Rvv3s/wD\
qNKGPs+q4z/bOsjdn7Tt3Z5xjzN3y7vN+ariKdkf7yYfudM4EGpEDM7YAK3GCF6qRhWPEIRsmqcUMn9\
o3x+xwY8jSl3fZLbOf7Z1lPL3f2hnbu+Tbjbj5N+356uJE5SM/ZYTmHTDk2sBJDzsFYk3oyXPDEgFwM\
OIx81XVa5n+9v8Aw/5f5afkJX/lv94W6nEH7yYfvo/uwak2P+JapyPKuBuOOMLhivzAiHCV+F//AAXh\
8ceCvhz+z/8As6+KfiF408NeBPDCfGL9qXQH8Q+M9bt/C+gJrvjP/gjj/wAFOvBvg/RG1nW9SgtF1fV\
vF+v6FpGm2xfzr/UNatLO1SV7mG3f90LeJyIMWsL5mjALWsD7idNVwp3Xq7gV+fB2gsd5Ib93WbdROV\
05hawsBeSEyG1gZkH/AAjV+25ZDehkO0hshGOWLY3EovHjsHDMsHjsBPEOnHGUZ03JcrcVKEldLTXtd\
2ucuPwkcfl+NwE5OnDHUatFySu4qrTcHJJ6NpSur6Nn8gfx1/ab/wCCSHxW/am+Lf7T/hP/AILRfs6+\
ANY+JPiXwB4x0vQPEP7JHwe+PE/gXxH8OvhZ8Pvhtp2reDfF3x1+HWuah4a1a6Hge3u5rjSzpgLxW0c\
sczWVvOfna08U/wDBLuBvhzcal/wcT6V4u1f4SfGbTvjx8M/FfxA+Bng34heOvAvxE0S40P8Asq50Hx\
9428N3+tw+EUfQdKvH8MvfyeHJ7zTI7q60qa9Czj+5eWJw90DawrthuiQLWBRGFgsiWUC9OwqGBBBYq\
ZSQGLMqDRPmP/RYRmacAfZYBuI1K3Qqf9N+YBiEAOAFcoCykyL+X4jwzli6levWzPCKWOqzrVIwpZzT\
hKrVqe3qSVKnxHCnFzqpVGqcILnSkkrK37pk/wBIDxSyHCZXgsq4i+q0ckw0MJhW8BlFWrTw1PDzwkK\
Pt62W1K84xwtarh17SpN+xrVabfLUmn+C/wABv+Czf/BGz4FfAD4I/Amz/wCCknwS8TQfBf4XfCP4WQ\
eJZrbxro8viK1+GWjaJ4ZOvS6Vb2Mq6XJdWmii7a2FxOITdmFZZXVpJPaI/wDgvx/wRvDW5P8AwUI+B\
yhYrcMfP8b/ALsrDdKy/JogJ2s6D5Cq/vfkCqHDfrpewyNEQLOByNS0fKtaWzhf+KiVeFbUFC8qV4J4\
jC9FVnuRROXtQLWFt0NqQDawMJA0F6QzA3o3lgpJJKljECQpVVf7SngeKqGFhRpcQZbCjR92Mf7LxPu\
xjCmlq85btZJa32vd30/I8VjHjsXiMdjHVxGLxlSdWrUnUTlUqVJuc6kn7PWU5Ntvq2z8ev8Ah/v/AM\
EcfI2/8PBfgdu/uef40/6B3ldf7C2/639309/9V8lR6n/wXz/4I5XFlqEMP/BQj4HPJPFdpF/pHjldz\
S6ZJCjZbRxtzKwTlgwzkt5fy1+wnlt9m3fZ4sf3/s8O7/kFeZ9/7Vn7v7z7v3v3n3/3VQazDJ/Z2qj7\
HBnyL5dv2S2xn+x5X8vb/aGNu359udu759+75K1p4bi721K3EOWp33/srEWWsen9senX9Lc98Pb+DP8\
A8DX/AMrP5yrj/gsb/wAE/PC/xN+OvjL4Qf8ABXf9iPw94a+NfjvSfiNd+G/iR+zt8cviNrmi69pXwV\
+D3wbms7XxV4b/AGifCkF5pNxZfCWwvEjl0hZIJtRnikmuIlgK6p/4Lk/sn5jx/wAFjv8AgnGcSzE/8\
YeftKfKrahBIrc/tpd4lZ+MHKfMTJtYf0WSxOHugbWFdsN0SBawKIwsFkSygXp2FQwIILFTKSAxZlQa\
J8x/6LCMzTgD7LANxGpW6FT/AKb8wDEIAcAK5QFlJkXwYcMZ7G7p8R4ekq1SpVcYUc2hHnrSlVqNQhx\
BGMVKc5S5YRjFXtFKKSX6JPxS4jq08JTxOCyjGPAYXB4KnPEcOcM4it9XwGGoYLCwqV6+S1K9aVLDUK\
NL2tapUrVFDmq1JzlKT/no+HH/AAVs/wCCMelfs+eNvgJ8YP8Ago/+zx8U9O+KWs/tCaj8ULvQ9H+Kn\
w20LxNYftJfFv4ofEjxvoWj6LBruran4Y0mG0+Juo2Fu66/dX6w26XEd7FeMXT5x8K/8F9f2ff2bvDf\
hf4Y6R+2N+yT+274V07xvoPgzwX8XvG37RvxA+C/xq8O/CfUdMzZa7+0Ppd5+z3q+m+OtS8K3IvdN1P\
xF4a1K517xPZppuqL4Qk1afWmk/qlWJ8yf6LCcTQAj7LAdpOpXCBR/pvygsChAyCqBCVUCRqekwyCy0\
ZfscAJ03TP3YtLYKc2NyRmMagQchGJ+YZ8oE4KqHKnC/Eqw+HWA4qwmUVcupww9OrQy2tOp7CMEo0qn\
1rNcRTrRXKnGVanUqwk5ShUg6lTn68B4q5h9c4hrcU8O5dx7l/FWYVc2xeBzOnXoYX+1K85yq47CSyS\
vk+Ly6pU9rKFahl2KwmCxNOOHp4rC1oYPBRw/wDOv+zz/wAFnP8AgmloPjP4x/HP9oL/AIKXfsxah8V\
vjCPCPhKw+H3wzuPHV78L/hF8HfhNc/Ea4+F/grQfFeufDjSdZ+Iniye9+JvjLVPEev6pZ2EdzqPiQW\
Gk6NpejaXbx3X1pJ/wX4/4I3lrgj/goR8DmDRXAU+f43/eFobVVX59EJG5kcfOWX9184ZSgX9e/Lb7N\
u+zxY/v/Z4d3/IK8z7/ANqz939593737z7/AO6qWWJw90DawrthuiQLWBRGFgsiWUC9OwqGBBBYqZSQ\
GLMqehgcp4oy+hSwtHiLAVIxdSblUy3FTnOdWo6tWcpPOPinUnKbUeWEeblpwhBRjH5DifiWvxZnWIz\
zMcHSw1atTw1CnRwsKeHw2Hw2CwtHBYLDUaUKelPDYPD0KEZ1ZVcRWVP22Jr18TUq1qn47R/8F8/+CO\
SXd9I3/BQj4HMk99FNE/2jxzzGttosRbD6OzDD2twcfKf3GQNxjYecp/wXp/4JW6H4h8X3mift2fsv6\
xpniTxJb69bT6p43+KGhX9sIvDvhHQJbe4srT4T6ghzL4dmnV0uSzJModVmVSP3DhhkW+1MGzgQnUoc\
KtpbIG/0Lw8vKrqDBuWC8kcSFejMyXGifMf+iwjM04A+ywDcRqVuhU/6b8wDEIAcAK5QFlJkX18O+Ls\
K5J53lWJhiKUKcozyvFpNfu6i1p53TldSpx1UlfW6s7Hx+YYDD5gsK1VxGCrYKq61OpRnQclJ0qtBpq\
thq0HFwrTTThe9mmrH4gD/AIOCf+CYWX/4zW/ZPGZIiP8Ai6PxZ+YLezSFuPgZ2Vg/OWw/ykS7mJX7f\
rE+ZP8ARYTiaAEfZYDtJ1K4QKP9N+UFgUIGQVQISqgSMUqlXiNPXE5Ktf8AoW5n2j/1UPocqyvEPbiD\
MV8ss8v+pX8zDsZ4UjnWOyuZU/tC4YPG/hoLmXX9QNwmDdr80aHD4G07TkyR7SbS3S5kzp15gTQBfn8\
NcqdSuEdhm/6CAI5xgbWAYGPaom0+5UxXB+0TnOpXfJl0ok+X4i1Jzko2DtByMdCcy/Jiri3AzJ+/m5\
mgb/Wabzt1K4lyctyQG3DHyhmJb9yVNe/UnapVvRi/fXWXePn/AF+XqadzNiulL2obTrwBobUyEv4aw\
jNBemRW3X5BIdYgd2TmQbiW2Fc+3uEVL50sbqSaS6R5Ykfw6JIJB4ds8RSn7YrFzIkf8T/65fmEo+Xo\
orgB7U+fMNkNqpIk00FdkF6uFLthQPMAG/5gHIf5jHWba3AK6innzEreIuwyaaVX/imrCPCqjeYBltv\
zfNhiB+8K1cJv97+6jblX2pfzr+t0HRf12CW6UPdBdOvCFhujGQ/hrDssFkY1XbfgAl2lA24OYztIbe\
WGulzHjTrzBmnDfP4a4UalbojHF/0MBdxnI2qQoEe5TpS3AL3R8+Y74bpQTJppLb4LJcMUbDA+WQdnz\
EIAnzCShrgZj/fzcTTt/rNN43alby5GG4JC7jn5Sygr+5DGsozfLS/cw6fan/L6/wCQK2uv9XRhxzwi\
/vX+xXJkMWmRmEP4a8xIV1fVgJmJu+YmidiAGIxG25Fj2hrSXSlIydOvATDphYF/DWQzzsLhTm/zlEw\
WzyQf3pZeKmiuV/tG+X7RP/qNKfHm6VjH9s6zJvxu3bsfNn/V7uf9VVxLgBIx58wxDpi4EmmgDyp2Yg\
BmyAucrn5lJzNhcVVWb5nejF/w+sv5afmv6+8NO5m290pEG/TrxSZow+5/DXyqdNV2Y+ZfngT5T5sjd\
yQZPmrPuLhGSxd7G6jmjuneKJ38OmSeQ+HbzMUR+2MwcSPJn5k/1LfMZT83RW9wFEH7+Zds0bfLJpo2\
401YsjzW4IPy/N8u3g/vsis26uAF05PPmBa8kXYJNNCt/wAU1fx4ZXbzCMrt+X5sKAf3gaqpzftJfuo\
pcr6y7Sv16/8ADW3Dotf60CW6UPdBdOvCFhujGQ/hrDssFkY1XbfgAl2lA24OYztIbeWGulzHjTrzBm\
nDfP4a4UalbojHF/0MBdxnI2qQoEe5TpS3AL3R8+Y74bpQTJppLb4LJcMUbDA+WQdnzEIAnzCShrgZj\
/fzcTTt/rNN43alby5GG4JC7jn5Sygr+5DGs4zfLS/cw6fan/L6/wCQK2uv9XRh3U8LxsstlcwoNQ0p\
keR/DRVymv5VFBu3wzIkIXAC/vl3FYwpS1FdKXtQ2nXgDQ2pkJfw1hGaC9MituvyCQ6xA7snMg3EtsK\
zXtyqxE/aJ13alo/Ky6UCf+KiV+TK2Dw4Py93J+4Y6uRXAD2p8+YbIbVSRJpoK7IL1cKXbCgeYAN/zA\
OQ/wAxjq3N+yl+6j8UvtS35Kf9dfRAt1qZH2v/AEbP9mX3mf3fM8O7v+QVv6/2hu/4+fk6/e5/1vzVF\
q08L2Gpo1lcxxtFexmZ38NGOOE6RITM4ju2zEJTghVYZHCGTmtfzh9m2+bL/u+ZY7f+QV5PTO/r8v8A\
u/L/AK/ioNZuV/s7VW+0T/6i+fPm6VnH9jyx787tu7Py5/1eOP8AW06c37ejajFO/eXePm/yFoQy3Sh\
7oLp14QsN0YyH8NYdlgsjGq7b8AEu0oG3BzGdpDbyw10uY8adeYM04b5/DXCjUrdEY4v+hgLuM5G1SF\
Aj3KdKW4Be6PnzHfDdKCZNNJbfBZLhijYYHyyDs+YhAE+YSUNcDMf7+biadv8AWabxu1K3lyMNwSF3H\
PyllBX9yGNZxm+Wl+5h0+1P+X1/yGra6/1dGat0uZM6deYE0AX5/DXKnUrhHYZv+ggCOcYG1gGBj2qK\
umTwpa6TGllcywrp+mr58b+GhE4FldZdQ92oCkpD99A371dw3BNu4twMyfv5uZoG/wBZpvO3UriXJy3\
JAbcMfKGYlv3JU1T0m5U2WjP9onIGm6Z8xl0osMWNyOGVtgx5gAz/AHzu5MVVzv2da1KPxLrL+X19fv\
22sK11qVPtf+jZ/sy+8z+75nh3d/yCt/X+0N3/AB8/J1+9z/rfmqWW6UPdBdOvCFhujGQ/hrDssFkY1\
XbfgAl2lA24OYztIbeWu+cPs23zZf8Ad8yx2/8AIK8npnf1+X/d+X/X8VLLcAvdHz5jvhulBMmmktvg\
slwxRsMD5ZB2fMQgCfMJKXP78f3MNn1n3j5/1+Rp3MOOeFL3UPLsrmUPqELSBH8NDyT9l0CPZJtu1Ut\
5PmScb12cE481KtNdLmPGnXmDNOG+fw1wo1K3RGOL/oYC7jORtUhQI9ymaG5Vr7Uz9onbbqUPLS6USP\
8AQvDz8GJsDhCfm7oD9wSVca4GY/383E07f6zTeN2pW8uRhuCQu45+UsoK/uQxqpTf7m9KL92H2pbez\
X9fqwXXX+rozVulzJnTrzAmgC/P4a5U6lcI7DN/0EARzjA2sAwMe1QVpLcDMn7+bmaBv9ZpvO3UriXJ\
y3JAbcMfKGYlv3JU0VzVZu+lGG/80+0PX+vuHG3f+rop6fNIYrgm8gYnUrv5hd2zA7PEWpMuGGngHYT\
uPA2g7m3g7RcWV8yf6VCMzQEn7VANxGpXDhh/oXzAMS5IwArhyGUiNSitasY+0re6v4i6ecRXfcIpXD\
2pF1Cu2G1AJuoFEYWC9AVibI7CoYgghiplAJYsrJm2srldRU3ULAXiARi6gZkH/CNWC7WjFkGQ7SVwX\
Y5YLncQ6lFXCEP3z5VfkXRfzxDovV/oaUsrl7om6hbdDdAkXUDCQNBZAqpFkN5YKAAApYxEAqVZnGlf\
Mf8ApUJxNOQftUB2k6lbuWP+hfKCwDgnIKoXAVQY2KKxjGPLT91aW6LsCb11/q6KcU0n9o3w+2QY8jS\
m2/a7bOf7Z1l/M2/2fnbu+fdnbj59m35KuJK4SMfaoRiHTBg3UAICTsVUg2RwUPLAklAcuZB8tFFXVj\
FSdopfw+i/lphd9wt5XAgxdQpiaMgNdQJtI01UDHdZNtAX5MncAw2EFv3lZt1K4XTlF1CoN5IDGbqBW\
cf8I1frtWM2RZztAXAdTlSudwLsUVVOMeeXur4X0X8sgu7LXv8AoaUsrl7om6hbdDdAkXUDCQNBZAqp\
FkN5YKAAApYxEAqVZnGlfMf+lQnE05B+1QHaTqVu5Y/6F8oLAOCcgqhcBVBjYorKMY8tP3VpbouwJvX\
X+rop3s0ixEi8gQnUtHyzXdsgb/iolbhm09g3LFuAOJA3RlVLkUrh7Ui6hXbDagE3UCiMLBegKxNkdh\
UMQQQxUygEsWVkKK0cIexfurWUui/kpgm7rUi8xvs237RFj+59oh3f8gry/ufZc/d/d/e+9+7+/wDva\
g1maT+ztVP2yDPkXzbvtdtjP9jyp5m7+z8bdvybsbd3ybN3z0UU6UY/WKPurfsv5oiu+5cllcvdE3UL\
boboEi6gYSBoLIFVIshvLBQAAFLGIgFSrM40r5j/ANKhOJpyD9qgO0nUrdyx/wBC+UFgHBOQVQuAqgx\
sUVlGMeWn7q0t0XYab11/q6BZXzJ/pUIzNASftUA3EalcOGH+hfMAxLkjACuHIZSI1p6TNIbLRm+2QE\
jTdM/eC7tioxY3IGZBp4AwHYH5TjzQDkspQoq1GPsq/ur4o9F/KwTd1qT+Y32bb9oix/c+0Q7v+QV5f\
3Psufu/u/vfe/d/f/e1LLK5e6JuoW3Q3QJF1AwkDQWQKqRZDeWCgAAKWMRAKlWZyilyx54+6tn084hd\
9ynDNI19qZN5A5GpQ4Zbu2cL/oXh5uWXT1C8qG5B4jLdFZXuNK+Y/wDSoTiacg/aoDtJ1K3csf8AQvl\
BYBwTkFULgKoMbFFVOEP3XurSMOi/59oE3rr/AFdAsr5k/wBKhGZoCT9qgG4jUrhww/0L5gGJckYAVw\
5DKRGpRRXNUhBy1inr2XaBUW779vzR/9k='
	$end 'DesignInfo'
$end 'ProjectPreview'
