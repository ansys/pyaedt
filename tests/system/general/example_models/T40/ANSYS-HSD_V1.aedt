$begin 'AnsoftProject'
	Created='Tue Jun 20 11:55:55 2023'
	Product='ElectronicsDesktop'
	FileOwnedByWorkbench=false
	$begin 'Desktop'
		Version(2023, 1)
		InfrastructureVersion(1, 0)
		$begin 'FactoryHeader'
			$begin 'geometry3deditor'
				KernelVersion(2, 0)
				ProjectContainsGeometry3D='0'
			$end 'geometry3deditor'
		$end 'FactoryHeader'
	$end 'Desktop'
	UsesAdvancedFeatures=false
	NextUniqueID=0
	MoveBackwards=false
	$begin 'HFSSEnvironment'
		Version(1, 0)
	$end 'HFSSEnvironment'
	$begin 'PlanarEMEnvironment'
		Version(1, 0)
	$end 'PlanarEMEnvironment'
	$begin 'Q3DEnvironment'
		Version(1, 0)
	$end 'Q3DEnvironment'
	$begin '2DExtractorEnvironment'
		Version(1, 0)
	$end '2DExtractorEnvironment'
	$begin 'NexximEnvironment'
		Version(1, 0)
	$end 'NexximEnvironment'
	$begin 'NexximNetlistEnvironment'
		Version(1, 0)
	$end 'NexximNetlistEnvironment'
	$begin 'EmitEnvironment'
		Version(1, 0)
	$end 'EmitEnvironment'
	$begin 'Maxwell3DEnvironment'
		Version(1, 0)
	$end 'Maxwell3DEnvironment'
	$begin 'Maxwell2DEnvironment'
		Version(1, 0)
	$end 'Maxwell2DEnvironment'
	$begin 'RMxprtEnvironment'
		Version(1, 0)
	$end 'RMxprtEnvironment'
	$begin 'MaxCirEnvironment'
		Version(1, 0)
	$end 'MaxCirEnvironment'
	$begin 'SimplorerEnvironment'
		Version(1, 0)
	$end 'SimplorerEnvironment'
	$begin 'IcepakEnvironment'
		Version(1, 0)
	$end 'IcepakEnvironment'
	$begin 'MechanicalEnvironment'
		Version(1, 0)
	$end 'MechanicalEnvironment'
	$begin 'FilterDesignEnvironment'
	$end 'FilterDesignEnvironment'
	$begin 'SchematicEnvironment'
		Version(1, 0)
	$end 'SchematicEnvironment'
	$begin 'geometry3deditor'
		Version(1, 0)
	$end 'geometry3deditor'
	ReadVersion=11
	$begin 'EDB'
		Path=''
		LastUpdateTimeStamp=1730736753
	$end 'EDB'
	$begin 'DesignMgrEnvironment'
		CompInstCounter=1
		GPortCounter=0
		NetCounter=0
		Alias('Ieee;Simplorer Elements\\Ieee', 'Std;Simplorer Elements\\Std', 'Basic_VHDLAMS;Simplorer Elements\\Basic Elements VHDLAMS\\Basic Elements VHDLAMS', 'Digital_Elements;Simplorer Elements\\Digital Elements\\Digital Elements', 'Transformations;Simplorer Elements\\Tools\\Transformations\\Transformations', 'HEV_VHDLAMS;Simplorer Elements\\HEV VHDLAMS\\HEV VHDLAMS', 'automotive_vda;Simplorer Elements\\VDALibs VHDLAMS\\automotive_vda', 'example_boardnet;Simplorer Elements\\VDALibs VHDLAMS\\example_boardnet', 'example_ecar;Simplorer Elements\\VDALibs VHDLAMS\\example_ecar', 'fundamentals_vda;Simplorer Elements\\VDALibs VHDLAMS\\fundamentals_vda', 'hybrid_emc_vda;Simplorer Elements\\VDALibs VHDLAMS\\hybrid_emc_vda', 'megma;Simplorer Elements\\VDALibs VHDLAMS\\megma', 'modelica_rotational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_rotational', 'modelica_thermal;Simplorer Elements\\VDALibs VHDLAMS\\modelica_thermal', 'modelica_translational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_translational', 'spice2vhd;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd', 'spice2vhd_devices;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd_devices', 'aircraft_electrical_vhdlams;Simplorer Elements\\Aircraft Electrical VHDLAMS\\Aircraft Electrical VHDLAMS', 'power_system_vhdlams;Simplorer Elements\\Power System VHDLAMS\\Power System VHDLAMS')
	$end 'DesignMgrEnvironment'
	$begin 'ProjectDatasets'
		NextUniqueID=0
		MoveBackwards=false
		DatasetType='ProjectDatasetType'
		$begin 'DatasetDefinitions'
		$end 'DatasetDefinitions'
	$end 'ProjectDatasets'
	VariableOrders[0:]
	$begin 'Definitions'
		$begin 'Folders'
			Definitions(1604, 10000, 1, 1, 0, false, false)
			Materials(1604, 9500, 9, 2, 1, false, false)
			'Surface Materials'(1604, 9501, 33503, 3, 1, false, false)
			Scripts(1604, 9502, 33500, 4, 1, false, false)
			Padstacks(1604, 9003, 12, 105, 1, false, false)
			Symbols(1604, 9001, 10, 103, 1, false, false)
			Footprints(1604, 9002, 11, 104, 1, false, false)
			Bondwires(1604, 9006, 12, 108, 1, false, false)
			Components(1604, 9000, 8, 102, 1, false, false)
			Models(1604, 9004, 13, 106, 1, false, false)
			Packages(1604, 9005, 33502, 107, 1, false, false)
		$end 'Folders'
		$begin 'Materials'
			$begin 'copper'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				conductivity='58000000'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'copper'
			$begin 'FR4_epoxy'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal', 'Structural')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=27
						Green=110
						Blue=76
					$end 'MatAppearanceData'
				$end 'AttachedData'
				permittivity='4.4'
				dielectric_loss_tangent='0.02'
				thermal_conductivity='0.294'
				mass_density='1900'
				specific_heat='1150'
				youngs_modulus='11000000000'
				poissons_ratio='0.28'
				thermal_expansion_coefficient='1.5e-05'
				ModTime=1499970477
				Library='Materials'
				LibLocation='Project'
				ModSinceLib=true
			$end 'FR4_epoxy'
			$begin 'Megtron4'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3.77'
				dielectric_loss_tangent='0.005'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Megtron4'
			$begin 'Megtron4_2'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3.47'
				dielectric_loss_tangent='0.006'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Megtron4_2'
			$begin 'Megtron4_3'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='4.2'
				dielectric_loss_tangent='0.005'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Megtron4_3'
			$begin 'Solder Resist'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3'
				dielectric_loss_tangent='0'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=true
			$end 'Solder Resist'
			$begin 'solder'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal', 'Structural')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=184
						Green=184
						Blue=179
					$end 'MatAppearanceData'
				$end 'AttachedData'
				conductivity='7000000'
				thermal_conductivity='48'
				mass_density='8000'
				specific_heat='167'
				youngs_modulus='69000000000'
				poissons_ratio='0.4'
				thermal_expansion_coefficient='1.59e-06'
				ModTime=1499970477
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'solder'
		$end 'Materials'
		$begin 'SurfaceMaterials'
		$end 'SurfaceMaterials'
		$begin 'Scripts'
		$end 'Scripts'
		$begin 'Symbols'
			$begin 'CAPC0603X33X15LL03T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'COIL-1008CS_V'
			$begin 'main'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0.00254, 0.00254, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, 0.000423333333333333, 0.00254, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'main'
			$begin 'MURA-BLM15-CHIP-2_V'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				ModTime=1687254942
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'WE-Coil-PD4-S'
		$end 'Symbols'
		$begin 'DefInfo'
			CAPC0603X33X15LL03T05(1002, 0, 0, 2, '', 1687254942, '', 'CAPC0603X33X15LL03T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X05N(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X05N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X33X10LL5(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X33X10LL5', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X10LL05(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X10LL05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X23ML05T8(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X23ML05T8', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X25LL05T10(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X25LL05T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X25ML05T10(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X25ML05T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1005X55X25NL05T10(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1005X55X25NL05T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1608X08N(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1608X08N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC1608X90X35ML10T15(1002, 0, 0, 2, '', 1687254942, '', 'CAPC1608X90X35ML10T15', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC2012X12N(1002, 0, 0, 2, '', 1687254942, '', 'CAPC2012X12N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC2013X100X20NL20(1002, 0, 0, 2, '', 1687254942, '', 'CAPC2013X100X20NL20', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC3216X180X20ML20(1002, 0, 0, 2, '', 1687254942, '', 'CAPC3216X180X20ML20', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC3216X180X55ML20T25(1002, 0, 0, 2, '', 1687254942, '', 'CAPC3216X180X55ML20T25', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPC3216X190X55ML30T25(1002, 0, 0, 2, '', 1687254942, '', 'CAPC3216X190X55ML30T25', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			CAPMP7343X31N(1002, 0, 0, 2, '', 1687254942, '', 'CAPMP7343X31N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'COIL-1008CS_V'(1002, 0, 0, 2, '', 1687254942, '', 'COIL-1008CS_V', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'MURA-BLM15-CHIP-2_V'(1002, 0, 0, 2, '', 1687254942, '', 'MURA-BLM15-CHIP-2_V', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'MURA-BLM15AG221SN1x_V'(1002, 0, 0, 2, '', 1687254942, '', 'MURA-BLM15AG221SN1x_V', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X35X25NL8T10(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X35X25NL8T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25LL05T05(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25LL05T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25ML05T05(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25ML05T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25NL05T05(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25NL05T05', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1005X40X25NL5T10(1002, 0, 0, 2, '', 1687254942, '', 'RESC1005X40X25NL5T10', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			RESC1608X05N(1002, 0, 0, 2, '', 1687254942, '', 'RESC1608X05N', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'SMD-0603'(1002, 0, 0, 2, '', 1687254942, '', 'SMD-0603', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'WE-Coil-744301047'(1002, 0, 0, 2, '', 1687254942, '', 'WE-Coil-744301047', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			'WE-Coil-PD4-S'(1002, 0, 0, 2, '', 1687254942, '', 'WE-Coil-PD4-S', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
			main(1002, 0, 16, 0, '', 1687254942, '', 'main', '', '', '', '', '', '', '', 'Project', '', '', 1687254942, '', 0, 0)
		$end 'DefInfo'
		$begin 'Compdefs'
			$begin 'CAPC0603X33X15LL03T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 0, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 1, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 2, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 3, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 4, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 5, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 6, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 7, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 8, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 9, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 10, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 11, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 12, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 13, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 14, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 15, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 16, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 17, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 18, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 19, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 20, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 21, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 22, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 23, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 24, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 25, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 26, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 27, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 28, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 29, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 30, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 31, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 32, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 33, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'COIL-1008CS_V'
			$begin 'MURA-BLM15-CHIP-2_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 34, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 35, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 36, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 37, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 38, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 39, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 40, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 41, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 42, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 43, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 44, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 45, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 46, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 47, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 48, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 49, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 50, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 51, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 52, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 53, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 54, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 55, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'WE-Coil-PD4-S'
			$begin 'main'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				$begin 'Properties'
					TextProp('Representation', 'SD', '', 'main')
				$end 'Properties'
				CompExtID=1
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'D', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'main'
		$end 'Compdefs'
	$end 'Definitions'
	DesignIDServer=2
	MoveBackwards=false
	$begin 'PlanarEMCircuit'
		RepRewriteV2=true
		Name='main'
		DesignID=0
		$begin 'Circuit'
			ComponentName='main'
			AutoFP=''
			$begin 'DesignDatasets'
				NextUniqueID=0
				MoveBackwards=false
				DatasetType='DesignDatasetType'
				$begin 'DatasetDefinitions'
				$end 'DatasetDefinitions'
			$end 'DesignDatasets'
			VariableOrders[0:]
			$begin 'Net'
				NetName='+VREFDDR4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_AVDDL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_AVDLL_PLL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_DVDDL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.8V_DVDDH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='12V-In'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1V0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='2V5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='3.3V_AVDDH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='5V'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='A10_GNDSENSE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AVCC_1V3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLOCK_I2C_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLOCK_I2C_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ACT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BG0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CAS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CKE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CLK_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CLK_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CSN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ20'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ21'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ22'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ23'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ24'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ25'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ26'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ27'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ28'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ29'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ30'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ31'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ32'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ33'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ34'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ35'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ36'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ37'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ38'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ39'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ40'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ41'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ42'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ43'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ44'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ45'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ47'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ48'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ49'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ50'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ51'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ52'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ53'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ54'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ55'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ56'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ57'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ58'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ59'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ60'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ61'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ62'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ63'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS4_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS4_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS5_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS5_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS6_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS6_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS7_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS7_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ODT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_PAR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_RAS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_RESETN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_WEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_3V3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_GTX_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_MDC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_MDIO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RX_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RX_DV'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TX_EN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GND_DP'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TCK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TDI'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TDO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TMS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TRST'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH01_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH01_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH02_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH02_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH03_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH03_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH04_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH04_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH05_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH05_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH06_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH06_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH07_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH07_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH08_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH08_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH09_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH09_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH10_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH10_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH11_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH11_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH12_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH12_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC10_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC10_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC177_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC178_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC179_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC180_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC18_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC19_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC19_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC25_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC26_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC26_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC271_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC291_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC33_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC34_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC34_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC35_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC42_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC43_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC50_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC50_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC9_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetD3_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC2_5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ3_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR100_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR102_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR104_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR105_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR106_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR108_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR113_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR114_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR115_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR116_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR116_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR117_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR119_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR11_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR120_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR121_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR122_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR123_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR124_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR12_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR13_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR1_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR22_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR24_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR25_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR26_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR34_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR65_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR66_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR82_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR83_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR8_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR99_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU13_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU13_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AP13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AV11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AW11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AW13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU9_46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_CLKREQ_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_REFCLK_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_REFCLK_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RST_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_SMB_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_SMB_DATA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_USB_D_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_USB_D_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_W_DISABLE_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_WAKE_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PDEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PLL_1V8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK0_FMCB_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK0_FMCB_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK_DP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK_DP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA__Mod_ABS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RS0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RS1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Rx_LOS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Tx_Disable'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Tx_Fault'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_TX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_TX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_VCCR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_VCCT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD4_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD4_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_D_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_D_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSTX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSTX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_VBUS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VDD_DDR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
		$end 'Circuit'
		$begin 'Layout'
			BlackBox=false
			DefUnits='mm'
			NIdx=5955
			ActLyr='1_Top'
			Tol(1e-08, 1e-08, 1e-12)
			$begin 'HfssExportInfo'
				ScriptFileName=''
				HfssFileName=''
				Version=2
				ExtentType='PolygonExtent'
				BasePolygon='poly_5949'
				BasePolygonEDBUId=5949
				DielExtentType='BboxExtent'
				DielBasePolygon=''
				DielBasePolygonEDBUId=-1
				DielExt(Ext='0', Dim=false)
				HonorUserDiel=true
				TruncAtGnd=false
				AirHorExt(Ext='0.15', Dim=false)
				AirPosZExt(Ext='0.15', Dim=false)
				AirNegZExt(Ext='0.15', Dim=false)
				SyncZExt=true
				OpenRegionType='Radiation'
				UseRadBound=true
				PMLVisible=false
				OperFreq='5GHz'
				RadLvl=0
				UseStackupForZExtFact=false
				Smooth=true
			$end 'HfssExportInfo'
		$end 'Layout'
		$begin 'Rule Set'
			$begin 'Data'
			$end 'Data'
			$begin 'DRCSolutionMgr'
			$end 'DRCSolutionMgr'
		$end 'Rule Set'
		$begin 'Workflow'
			WorkflowName=''
			SpecName=''
			TemplateName=''
			LibLoc=-2
		$end 'Workflow'
		$begin 'Port'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Port'
		$begin 'Boundary'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Boundary'
		$begin 'Cavity'
			$begin 'Data'
			$end 'Data'
		$end 'Cavity'
		$begin 'Via'
			$begin 'Data'
			$end 'Data'
		$end 'Via'
		$begin 'LayoutVia'
			$begin 'Data'
			$end 'Data'
		$end 'LayoutVia'
		$begin 'Source'
			$begin 'Data'
			$end 'Data'
		$end 'Source'
		$begin 'Voltage Probe'
			$begin 'Data'
			$end 'Data'
		$end 'Voltage Probe'
		$begin 'DC Terminal'
			$begin 'Data'
			$end 'Data'
		$end 'DC Terminal'
		$begin 'CircuitSources'
			$begin 'Data'
			$end 'Data'
		$end 'CircuitSources'
		$begin 'NexximPorts'
			$begin 'Data'
			$end 'Data'
			$begin 'DiffPairs'
			$end 'DiffPairs'
		$end 'NexximPorts'
		$begin 'SortOrder'
		$end 'SortOrder'
		$begin 'NexximMultiComponentContainers'
			$begin 'Data'
			$end 'Data'
		$end 'NexximMultiComponentContainers'
		$begin 'ComponentConfigurationData'
			$begin 'EnabledPorts'
			$end 'EnabledPorts'
			$begin 'EnabledMultipleComponents'
			$end 'EnabledMultipleComponents'
			$begin 'EnabledAnalyses'
			$end 'EnabledAnalyses'
		$end 'ComponentConfigurationData'
		$begin 'Properties'
		$end 'Properties'
		$begin 'CustomSimSetups'
			$begin 'Data'
			$end 'Data'
		$end 'CustomSimSetups'
		$begin 'RadSetup'
			$begin 'Data'
			$end 'Data'
		$end 'RadSetup'
		$begin 'Setup'
			$begin 'Data'
			$end 'Data'
		$end 'Setup'
		$begin 'AnalysisOptionBlocks'
		$end 'AnalysisOptionBlocks'
		$begin 'EM properties'
			$begin 'Data'
			$end 'Data'
		$end 'EM properties'
		$begin 'OutputVariable'
			NextUniqueID=0
			MoveBackwards=false
		$end 'OutputVariable'
		$begin 'Optimetrics'
			$begin 'OptimetricsSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'OptimetricsSetups'
		$end 'Optimetrics'
		$begin 'FieldsReporter'
			$begin 'FieldsCalculator'
				Line_Discretization=1000
			$end 'FieldsCalculator'
			$begin 'PlotDefaults'
				Default_SolutionId=-1
				Default_PlotFolder='Automatic'
			$end 'PlotDefaults'
			$begin 'FieldsPlotManagerID'
				NextUniqueID=0
				MoveBackwards=false
				NumQuantityType=0
				NumPlots=0
			$end 'FieldsPlotManagerID'
			$begin 'Report3dInGeomWnd'
				Report3dNum=0
			$end 'Report3dInGeomWnd'
			$begin 'Report2dInGeomWnd'
				Report2dNum=0
			$end 'Report2dInGeomWnd'
			$begin 'AntennaParametersInGeomWnd'
				AntennaParametersNum=0
			$end 'AntennaParametersInGeomWnd'
			AntennaParametersPlotTablesOrder()
			$begin 'EntitySelectionCache'
			$end 'EntitySelectionCache'
		$end 'FieldsReporter'
		$begin 'SolutionManager'
			$begin 'SimDataExtractors'
				$begin 'Version ID Map'
					V=4
				$end 'Version ID Map'
			$end 'SimDataExtractors'
		$end 'SolutionManager'
		$begin 'InterfaceOptions'
			SchematicEnabled=false
			SaveBeforeSolving=true
		$end 'InterfaceOptions'
		$begin 'AdvancedSettings'
			ComputeBothEvenAndOddCPWModes=false
			CausalMaterials=true
			MeshingMethod='Phi'
			EnableDesignIntersectionCheck=true
			UseAlternativeMeshMethodsAsFallBack=true
			CircuitSparamDefinition=false
			CircuitIntegrationType='FFT'
			BroadbandFreqOption='AutoMaxFreq'
			BroadbandMaxNumFreq=5
			SaveADP=false
			UseAdvancedDCExtrap=false
			ModeOption='General mode'
			PhiMesherDeltaZRatio=100000
			SpiceType='TouchStone1.0'
			EnforcePassivity=false
			EnforceCausality=false
			UseCommonGround=true
			ShowGammaComments=false
			Renormalize=true
			RenormImpedance=50
			FittingError=0.5
			MaxPoles=10000
			PassivityType='IteratedFittingOfPV'
			ColumnFittingType='Matrix'
			SSFittingType='FastFit'
			RelativeErrorToleranc=false
			EnsureAccurateZfit=true
			TouchstoneFormat='MA'
			TouchstoneUnits='GHz'
			TouchStonePrecision=15
			ExportAfterSolve=false
			ExportDir=''
		$end 'AdvancedSettings'
		$begin 'CoSimOptions'
			Override=false
			Setup=''
			OverrideSweep=false
			Sweep=''
			FrequencySweepType=0
			Interpolate=false
			YMatrix=true
			AutoAlignPorts=false
			Simulator=1
			InterpAlg='auto'
			Renormalize=false
			RenormImpedance=50
		$end 'CoSimOptions'
		$begin 'TemperatureData'
			IncludeTempDependence=false
			EnableFeedback=false
			Temperature='22cel'
		$end 'TemperatureData'
		$begin 'UserDefinedSolutionMgr'
			NextUniqueID=1000000
			MoveBackwards=false
		$end 'UserDefinedSolutionMgr'
		$begin 'DatasetSolutionMgr'
			NextUniqueID=2000000
			MoveBackwards=false
		$end 'DatasetSolutionMgr'
		Notes=$begin_cdata$ $end_cdata$
		$begin 'AnimationSetups'
		$end 'AnimationSetups'
		CacheHeaderFile='HDR026412984017307367534.tmp'
	$end 'PlanarEMCircuit'
	$begin 'DataInstances'
		DesignEditor='TopLevel'
		Refdes('0', 'U1')
		$begin 'CompInstances'
			$begin 'Compinst'
				ID='0'
				Status='Status'
				CompName='main'
				GatesInUse()
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '0')
				$end 'Properties'
				$begin 'Parameters'
					ButtonProp('CosimDefinition', 'OHD', '', '', 'Edit', 40501, ButtonPropClientData())
					MenuProp('CoSimulator', 'OHD', '', 'DefaultNetlist', 0)
				$end 'Parameters'
			$end 'Compinst'
		$end 'CompInstances'
		$begin 'Instance'
			DesignEditor='main'
			ID='0'
			$begin 'PlanarEMItem'
				Editor3D=true
				$begin 'PostProcessing'
					$begin 'Fields'
						$begin 'Items'
						$end 'Items'
					$end 'Fields'
					DesignInstanceID=1
					$begin 'WindowPosition'
						$begin 'EditorWindow'
							Circuit(Layout(View(WindowPos(3, -1, -1, -8, -31, 0, 0, 136, 50), Extent(-0.880303025245667, -1, 0.880303025245667, 1, 124149.806071328, 123994.966714253, -0.00693838158622384, 0.0408204905688763, 0.0110833793878555, 0.00408080965280533, 1), ViewingXfm(-2.71597599983215, 2.71597599983215, -1, 1, -226.236145019531, 226.725463867188, 405.695373535156, -39.9712066650391, -272.048675537109, 0, -206.875793457031, 275.056610107422, -348.916625976563, 0, 181.138809204102, 403.661376953125, 210.814010620117, 0, 0.68451714515686, -19.0060615539551, 33.5877227783203, 1))), Layout())
						$end 'EditorWindow'
					$end 'WindowPosition'
					$begin 'ReportSetup'
						$begin 'ReportManager'
							$begin 'Reports'
							$end 'Reports'
							NextUniqueID=0
							MoveBackwards=false
							$begin 'NextVersID'
								NextUniqueID=0
								MoveBackwards=false
							$end 'NextVersID'
						$end 'ReportManager'
						$begin 'Reports'
						$end 'Reports'
						$begin 'ReportsWindowInfoList'
						$end 'ReportsWindowInfoList'
					$end 'ReportSetup'
				$end 'PostProcessing'
				$begin 'Properties'
				$end 'Properties'
				$begin 'UserDefinedDocument'
					$begin 'Data'
					$end 'Data'
				$end 'UserDefinedDocument'
			$end 'PlanarEMItem'
			$begin 'TopLayout'
				DefaultUnits='mm'
				DefaultAngleUnits='deg'
				MajorSize='10mm'
				MinorSize='1mm'
				PixelSnapTolerance=20
				SnapAcrossHierarchy=true
				SnapTargetVertex_on=true
				SnapTargetEdgeCenter_on=true
				SnapTargetObjCenter_on=true
				SnapTargetEdge_on=false
				SnapTargetElecConnection_on=true
				SnapTargetIntersection_on=false
				SnapTargetGrid_on=true
				SnapSourceVertex_on=true
				SnapSourceEdgeCenter_on=true
				SnapSourceObjCenter_on=true
				SnapSourceEdge_on=false
				SnapSourceElecConnection_on=true
				ConstrainToGrid=false
				DirectionConstraint=0
				defaultholesize='25mil'
				anglesnap='5deg'
				$begin 'TextStyles'
					TextStyle(N='<DefaultAnnotation>', F='Arial', Hght=12, Scale=false)
					TextStyle(N='<DefaultPlotter>', Plot=true, F='RomanSimplex', Hght=5, HghtUnt='mm')
					TextStyle(N='<DefaultMeasure>', Plot=true, F='RomanSimplex', Hght=1, HghtUnt='mm')
				$end 'TextStyles'
				$begin 'TraceStyles'
					TraceStyle(name='Half Grid', size='0.5mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='1 Grid', size='1mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='2 Grids', size='2mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='5 Grids', size='5mm', bendStyle=0, capStyle=0, capStyle=0)
				$end 'TraceStyles'
				'current via style'='PlanarEMVia'
				'current pin style'=''
				MajorColor=16772075
				MinorColor=16774645
				ShowGrid=true
				PageExtent(-0.1, -0.1, 0.1, 0.1)
				'background color'=16777215
				DefaultToSketchMode=true
				fillMode=false
				DocVisibilityFlag=962
				FastViewTransforms=true
				StartingHierarchyLevel=0
				EndingHierarchyLevel=-1
				SingleLevelView=false
				'show connection points'=false
				'draw rats'=false
				'display vertex labels'=false
				ColorByNet=false
				'display package graphics'=false
				'rectangle description'=0
				snaptoport=true
				autoplacecomp=false
				'sym footprint scaling'=4.1163018385
				AutoScale=true
				'measure display digits'=3
				'display measure units'=false
				SuppressPads=true
				AntiPadsOption=0
				TextIsVisible=true
				'primary selection color'=255
				'secondary selection color'=3289780
				'preview selection'=false
				AllowDragOnFirstClick=false
				PinConnectivityPopup=false
				CreatePortsOnComp=false
				OptionUseNamingConvention_PadPort=false
				OptionNamingConvention_PadPort='$REFDES_$PINNAME_$NETNAME'
				useFixedDrawingResolution=false
				DrawingResolution='0.002mm'
				$begin 'ViewConfigs'
					ViewConfigsCurrent=''
				$end 'ViewConfigs'
				currentTextStyle=0
				currentTraceStyle=0
				prevBounds(-0.880303025245667, -1, 0.880303025245667, 1)
				prevMapFactor(124149.806071328, 123994.966714253)
				prevOrigin(-0.00693838158622384, 0.0408204905688763)
				prevViewExtent(0.0110833793878555, 0.00408080965280533)
				prevZoomScale=1
				$begin 'Animation'
					LabelColor(R=230, G=230, B=230)
					FontName='Arial'
					FontHeight=24
					FontWeight=400
				$end 'Animation'
			$end 'TopLayout'
		$end 'Instance'
		$begin 'SODInfo'
			$begin 'CAPC0603X33X15LL03T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'COIL-1008CS_V'
			$begin 'MURA-BLM15-CHIP-2_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'WE-Coil-PD4-S'
			$begin 'main'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'main'
		$end 'SODInfo'
	$end 'DataInstances'
	$begin 'WBSystemIDToDesignInstanceIDMap'
	$end 'WBSystemIDToDesignInstanceIDMap'
	$begin 'WBSysIDSysDetails'
	$end 'WBSysIDSysDetails'
	$begin 'WBConnIDConnDetails'
	$end 'WBConnIDConnDetails'
	$begin 'WBMaterialGuidDetails'
		WBMaterialGuidMap()
	$end 'WBMaterialGuidDetails'
	$begin 'MinervaProjectSettingsBlk'
		MinervaRemoteFilePath=''
		FolderContainerString=''
	$end 'MinervaProjectSettingsBlk'
$end 'AnsoftProject'
$begin 'AllReferencedFilesForProject'
$end 'AllReferencedFilesForProject'
$begin 'ProjectPreview'
	IsEncrypted=false
	Thumbnail64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCABgAGADASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+ztv2gfi6VIH7Bf7XqkggMvj79h/cpIwGG79tg\
jI9wR6g1g6Z+2j4KuLSabxT8Hv2zvh34u03VNf0LWfBuvfsYftEeOb3T5tA1/UNGlNv43+BXww8W+EP\
FGl3i6bHfabqOheI9Y0+5sdSt5luFeSWOL+Hn9sz9nv/AIJY61YfD7Rf2dP+CN//AAUb+Hmk6Z8eNT8\
F/Fbx/qfjT47fDDWtU1PRtE1DQZPgF4J1DXvGXxU0+1+Kg8ReJ7DxBPY63oelS3Ol/C26sbG6+0azaX\
C6fwM+MvhLxd+0x4d8AfE7/grf/wAFiPh54H8SeJvBnw38d/CLV/20viB4C+K/7M/jHxPp9jp994t8V\
/Ej4jWeuaH42+HWg+N7LVrbxtHq1z4V1fQLXxjpN/pNtrFtpmp2TdWN4h8AMPx1gOH8o8deJYcM16En\
XzjiLgPAUKGGrTVB0ITwWScVZliI06rdahOs8Q50qypRng3SqVMRhP7CyXwC4z4rynEU5+CGBlxFQni\
ZRyzhnOuI6eZp4HB4jG1qdbGZrl3EWQTpYnA01i8D7OvQljZRhRwmMq4j2mCn/bxaf8FBP2RYda1Hwz\
4y+O+g/BbxFp2k6P4gXQf2nvCXjn9lbX9W0DxDfeINO0rWfDOlftG6B4Sm8ZaV/aHhfXLae50iG7htZ\
rDyrtoJJYVk9A8Gfta/st/FTxPpngP4a/tO/s2/Enxvrf2uTw94T8DfGn4d+JvFeoz6Vp97rN/JpXhv\
QfEl7d6n9m0rT7y7m8mM+XbWU8soEKSMP5xP2xfjfo37Dv7MR1/9mP8A4OT9Xhsvhv4X+KutReDfj7a\
/sZf8FAfix8XvF39nah4z8HeE9J8e6V4AsvF+irdeILfVNJbUNcbxRb258SaJp1iunQWVpp99+TX7O/\
8AwV4/4Kv/AB4+HXjfwfqfxg/YJ/4KUXHj5/CUQ/Zb/aV/Zi07w1410yPw5rFvqE1/4a8BfDTUfCunf\
E5bjxTfaLYW+nQjxhrF94p8M6Za+GrC1WLVNQf1OJMu4H4dlk1fDfSR4Nz2ln+Jr0sPSjkfHGDqUadP\
FwoUf7Rxcshr5Rg6talOOIlDDZnmPsKSqSnGU1To1fhMq8LqXEMMyjh/CLibhV5X9Wo4qeacX8KUsTh\
KuIoc8MT/AGTmWW5DjMXQqzhVeEpyqYGljKkVgKWYxxHNWj/oTxXNyxdHghaSEhJkhuMy7mUFHSOWNV\
CMCGGZOFJGS6lalaZ2Uq1jcMrAqys1mVZSMEEG65BFfzM/s+/sm/t5+PIvhf8AF7xF+wr/AMG4XxV+B\
Hjnwjp3jmw0/wCGvwn/AGhfgx408YeE/GfhI614K1DRvFXxB/Z28Ux+EWabU9Avp4tR8K3Vy9tDPp7x\
afcTm6tee8Nv/wAFIPDXh7QvDfhL/ghb+054d8K+HdH03QfDfh/w/wD8HF/jHR9B0HQdHs4dO0jRNF0\
jT/ivFb6TpVpYW1vb29rBHHFbxW6QxxoiBR+iUvAjj/M8Q1w1xT4bcQ4KnRo1Z4peJ3DGU0VKu6nJSp\
LiPE5JVxMuSlKrUnhadalShUoqVVzqWj+XYnD+FeXVMXg824j4wyzNsHXlRnhqvBWG56cqblGvGuocU\
ynQrUqijTdGdPmcva8zpumoz/p+gu1hP2ed7iRiT9nd7S5Es0YXJVx5WZJkwdzAYKlW+8WAsi9tCWDT\
pGynDJOTbyAlQwzHOFbG1hg4wc1/Mpqn7Yvxo+B2s6v4J1L9k7/g44+G/imaLwj4l8YeAvhD8K/2bf8\
AgoX8GvBXjXV/h74PbXtE+Ev7U/xjtPiBq/xC8FpdwGRtviCGCPULzUlk0Pw9fS3+jWe43/BVS1+Efh\
HTfjJ8cP2lP29P2NvDM3iDV/hhe+DP+Cqv/BJnxTreg+KPEup6VoHizwj4l+Hni79irwF4FsdG1T+zd\
D+INrFpuq+LNUvL+Cw1K6fw7ZQ6fZ6ldzU+j34/SoYSvgPBvM+KqmYTpww8OHcbkvELxntWnSr4CnlO\
YYjEYzDVabVaFehh3CVJqpH3ZR5oWTeHtetJ4bxnyXL8G6XtY/2rl3E2DxNNql7R4fFUsLkeZYajiVU\
/cONHHYrDqrZrEuleqv6RhdQQzsy3UMltMcuiMj/ZpmIHmkxn93bux+ctwJHBz87EadfzhfD/AP4Ld/\
Az4u6zNo/wv/4Ka/8ABNzxh4k0CHSvE994S+Pv7M37VP7C/g7xP4StPFvhrTPF+jaV+0N8cPjTrOleG\
vGcmg6teSaXDb+HfEt5JPa/aH0SfTbXUbq0+sfCX/BTbw94z8S+HvAfg/4rf8EhfGPjLxXrmj+HPB/h\
zwt/wVntdZ8UeJ/EWvalb6V4f8OeH9L0T9j2W61vxLd6rc2lta2trG9zdzXUUUMUkj7T87nvhR4xcL4\
ivg+MPBLjThHH4SlGtUo47hfN4TjQab9tL2WFqRpwUYtt1XB8tp2cffdU+DcLj6NPFcOeIPC3EuFqTl\
TlOGe4TKpU6kVCXI6HETyXFVIyVROFahQrYdtTp+29pCcI/sFcJIrLcwk7ogfNiCb/ALRADuaMAcmZf\
mMfOAzFTw5qeOWOaNZYmDxuMqw6EdO/Qg5BB5BGDzXyN+z7+1HpPxf8U+Ifg58RPh342/Z4/aZ8CeEv\
CnjPxv8AAb4ia9oOsajceFvEunaeG+IXwp8beDfEF7pPxf8AhLD4tuNT0GTXNNlhubLVdHay1/SNCvb\
m0tJvqiSNrRw32yeO0kYhvlhcwzORsdpJIW2wHBDFufMYMzMXZh+eYHG4PNMNGvg6/tIXlHWEoSjKDc\
Z0qlOUVUhVhNOMqdSMZwknGUU7JeTxPwvn3B2bVMl4iwH1HHwp0a0eWrRxFCvh8TShWw2LwmLw1SthM\
Zg8TRnCthsZhK1bDYmjOFWhVqU5KT/DD/go7+z1qvivxhqHhT9nvXPDej6p4z1A/Eb4g/Bjxn4YsvH/\
AMFPiZ8XdW8LeMfB2ha5deHtEhtPE3wg+Klzb65pU154j8J61bXOoxy2t3qGhaveBLif8rPFH7Zul/s\
Tftdfs9+H/B37H3hb4w/tK/ADSNV/ZM8W+L/gX/wUB+M3xG034h3/AIt8C+DtS+JX7P8A8PPgH4l8Ja\
7e+GfBEnxz134UalYQajpiyweLfhtrPhnRludS0jXbgfJv/Cjv2WvGH7KnxW/bq/Z3/wCCcmjftH+Hv\
h94L8S+IdV8C+Ev2pfjZNf/AA08b3WntY6Bo/xR8M+IPGukataeHPDuqalbaxrz6dqN21v4X8J3erxa\
mdPn07U7v8GPHXxG+NsOo6p4s+MPwO+PP/Cw/EWl2XxK8XT+ItS8B+JfFHiGbx7oln8QU8VC71P4hR6\
v42/tvTNetdWsNRNobnXLfW7fUII5Ptse/wDm3j/jDMsJLKc4yTJsowPEOOUFTzKNbDVMZ9XlCSVKlL\
NMvwdV0avPJUqtKFalKUKsJcrhOnU/0/8AoO/Rg+jb4t8VeJtfj6XiFxDkXhnVr5bjMo4g8N+LeFaUc\
ypxwuInW+uZHm+ZPEfUKNWnHMsNHG4X2CxVOEatSrKVbA/1I/tIf8FIf2Df+CiOj+CvGPxD+F3gL4Ef\
tV+BfCHjHwnpJ/aY8B6N8WP2aPiN4c8beIIfDtt8FvGPxl8F6Cvi/wAPadPZav8A2zZa3Lo/hrTvCt1\
c69Lb6zpWpPpnim38W0L/AIJnfD39r/8AZz8b6ZN8LfiL+yLeN4V0vxp8EvEPwS/Zl8NfteTz+KrjXf\
EHi3Q734TfH79m3xLo1v400xfCVt4d0+XQfiTcJpj2HxHivbC7S/07QvFugfzd+DPGPgz4z3/gfwHc6\
L+0h4L+InjfxnZeHfDHhYfs1698Q7LVZPEdvqegeDpSvwt8V614lHiCb4hR6bYXOh2/ha41M6Pry61o\
1vr959h0K/8A60P+Dab/AIKJ/CkfBz4z/sxePfjR4S0fw78M/iHpN58L4fH974x8Nav4U1/xPpXirVv\
id4d1ZPGe2z+HPgyPWvC9hqOlwXdvo9rqHiHxb4mhtbrVtRe7tbF8HYnG8T5jlWG8ReGqdfE1nV5M1w\
vNhVF04wqOjmNbA1YUKlKvU5b0KrjQqV3Gi6Eqqahv9NngD6P/AIJcKZ54ofR/+kbifDPJeD6+T4dcO\
Z7xJisunWec5hLA4SPDEc6q4LNakqNX2fJQ5sdVqYOm8dHEKhUoTxH7ufBD/gmP8AvAHwH03wj4R0j4\
6/st+LfGng6x1nx7pX7Pv7YP7UvhHS/B3xa8QeDNL0vxN4i8PaPB8c9V0LVtc03UrWCKyuNSttctJo9\
AsorsalZxhJL3w5/4J3eJPg94hufE/hb/AIKL/wDBR/UZr/S7jRbyH4lfGv4U/GTRIIr27sLtr238L/\
GH4Da9pVtqhuNOtY1v4rKO/gjlmijukt7q7jl+p4v2tv2ZTvSX9ob4DGWJgjmD4zfDUxv8qsJE87xQj\
BWycDBx0J3Agfz/AGgf8Fgf+Cner/ts63+xbD+xF8CNc+IHgrUtKvfFHgjV/iTJ8H/H/jDwTBpmieIP\
Fd98MB8RPHUmjeKLs6Fd68+lTWN/qsF9b+Gr/V4Yp9KsL6WD9kxuW8F5PHA4ieDpYKEKlPDUFl8asWq\
la/soQp5d73NOzVOXJvaKevK/4W8N/GHxx8bsXxlkvCHibT8UsRSwNfN88lnWb5Jm8IYDCwTxGKxuN4\
mr16UKMIL2k4Trx54U6lbkkqNScP1Pb9lb/gpHYeOjr2jf8FWX1DwTZeLTrGleAfHn7DfwD1w33ha31\
j7bY+DvGnirwRr3hi71jzNJSKy1HUNHj8PXNx5k1zYLpMjwrb3/AIoaT/wV/wBI8QWv/Cm/G/8AwTe8\
d+Ghosc2oal8R/hZ+078KNeXWmvL8XGlW3hvwv8AF/xpBqGmRWEWmywXrarbTST39zbtYQxwJcXfwV+\
0D/wWv/ak/ZdtvHTfFb/gj7+1D4e0vwJFYrL45vPiJ4Rufg4Z9bj02PwzBdfGXwz4Y1XQorC41LW9Es\
WuLe5vJre7v/sM9p/akUtiP4wviv8Atk/tFfFT4taf8cfij4u+Oni74vWGpP4g8NePT4gsbjW/Bd1ou\
vX/AI30638CXPh/xSsXw303T/Eep395ommaOunWdhc3JTRrSFwsY/OON+Mcg4Olh8BlVTMs1zLHTnOr\
TWdYunUoU6bSlzRzCriXDmfOo0oUUk6VRSlScVf+8fov/Ru8XvpFrOOKeP8AB8FcA8EcLYbDYfA4up4\
Y8O4rB5xicZCU6EaNThDAZLHEKjFYadXHYnM6k5Rx+ElQo45Vp8n+hh8TvHv/AAUHt/g3B4f8X/sEfs\
sftaP4y0JfAXxS8C/Dr9rW40Hwz4t0rxB4Z1Kw8b32peBf2if2bLDSk+G98UubGfRLrxDrt8IfEUNnM\
mpWyX15H8P2nwm/ZW8AfDXxF8SP2uP+DfT4HfAHwz4V1SC58VeLfhn8H/2Cf2mvC3gj4emfRIL74leL\
LPwUmm+LJNF0p7zWL3XbfRvCGttp2iaDLqhlnj+1Q2X4G/sN/wDBxF+0d+zPr3hrwl+05q3jP41/Aub\
xXb6N4gk+KWm3upfGHw5pt5d+IL3VNX8BfF+XUfI8VXb6lri3RtvFuo6nb3Fp4St9I0vUPDFhK2pRf3\
I/s2/tCfDj9qv4H/Dz9oH4TXOrXPgL4kaTc6lpCa/pUui67pt5pWraj4d8RaBrWnPJIkWrab4m0fWNP\
uXtZ7qwmm0x59Ovb6xkt7yf9G8NfFnifE0sTDgbxR4j4QxVSm6tTLVXw+HpTnSUKaxM/qdCjLG04TnC\
EqlPGRk1KMZewlONvxL6R/gNjvo71qOH8QfAHgnjLg7G5jSpLivh7M+MaOJl9ZeIxMcqdHG8RV8FkGZ\
1cHhcVUw9DMOGcRTg6FWphlmeHwtW/wCFP7Rf/Bux/wAEuv2ivAt18WP2Z/gT8PvA/wAVtd12w+Mvgj\
xNoHxM+Ml5+zz8SLfxBK/iiT4f6z4R+H/xWS28N/s+eKLHU4o4pvh9Ho8+h2o03UPDRa001NJvfQvht\
/wTr/Zg/at+HHgnxd+yp+3P/wAFcP2Sfhn4A8OWvwU1L9mv4S/tufG7w1D8F/GHw2kuNL1r4YfEH4ef\
G8+NdV+GPxC0CxuNJ0W50Gz1K10K303QdLudGsZLK8TVNT+lPgokn/BOj47eFf2Or4nTv2Kfi+Nc1T9\
kD4geJ08r/hXPxv8AFPjHV/Efin9ifVvFtt9oPiqbU/7R17xP4B1XxRLpWsXjXN/4Rgv/ABlqMMUlh7\
B+01e+N/2XPG5/bU8A62NQ+B9wPBeh/to/BxvDWs6naXHgS31mx8MH9rvwG3gLwnqOrw/FvwN4Tv7T/\
hLku7W9tPEvw5+H1tYXE2l3Xg/QLhf3DB/Sp+kBh5/6w5h4ucSZj/Z0lSzbL8yzjG51hMJiKeFoUI46\
jhc3r4nB2pYOlRjDExwn1itlkcNy8k8HHDH4PmXg9wxiq+F8OMlw2DzKjxZKWa+HvEEMHhsvq59h8XW\
dB5FmrweErYh5riMTh45dTwuIzGeCyLiTDY3ARr1cuzSWa0/zRv8ARoP+Cemq+Hv2q7vxbonxM/4Jw/\
twXFha/tnfCvw/4OtfjP8ADDwvq/xb8EXOk+B/2nfAj+DbSTR9V+HniTTofBmnePLsNqSeIP8AhJAbe\
HxpqOseGrfw9+Yn7W/7K/7H+ma/8bbr9lT9qH9lH9q6w05Pg58ZLf4TfFD4+Wdh4z+Dngf4Rz2XgDwz\
8EdI/aUm8WtY+OvgzffDLXfH1nd+CpvF/wAP/Gtnonwy8B3+k67rk3hxota/dP8AZf8ACHjH9loS/An\
9pn4N/s3/AAG/ZE/bO8QXTfBT4CaH8Tb/AOJ3hf8AZ1/aC+LfgbRNb+KX7E94PEfgjStB8W/D7xp4tj\
+N/iXw0uj2Om+G7LVG1vwZa2s0Gv8AgzTpP4d/+Clv7Tvh3Rfj5/wUJ+BHgD9j/wAN+HvhZoH7V3xv+\
H3wV0z9n1/gMnjz4VfFD4Y6Jonwuv8AxZr+kaZ8EJfHd58GNV8faR4+8d2/h271TT/CE2o+KW8LaPcv\
L4buNRtfw+PgnmviJkXHme5dl+CrcOcBulXzSeNzGlgJZLXzKUsN7XDYnFfWY1sHmE5upQw6wNelTq1\
J1JKjKcI0f6F4H+l1jvAqnwHn8s0zjKcwzjL8FR/tPLcBlWNyninh3KMTRrZRHiTKama8J4rC5/w9Vw\
jynNc2wvE+DzCeCwOGw1SpjMLCpXzT0TwR+wp8cPjH4y1qT4afsqfHjxHMW8G+BvAmvaJo3iOPwB4s8\
Ua74snsdF+O154pl8NeJvCWnfC2++H2g51KNfiQmj2viDxrbeKvD3ie48FWM+h2X9XY/Yy+I/8AwSS+\
EHwG/at+BXizVteg+C3w88E+Ev8Agor8GPDfhuLxppPx++HF98QNX8W/Ef4r+BI9K0Dw/caj8Q/Amof\
Efxi/h7WPETWL2XgfwzYQ6pq9jpmka9pniv8Aiz/YG+LPwr+F994K+I/w28eXEfxe/wCELvR8T/g5rf\
izxL+yF4k+FOjeI/AvifXNS+KX7MPxusPjfYR3Xxov/C2lw2eh6E3h/wAT6JfxfFaC11Pwx4u1SbS7X\
Xf7Dvi18L/2ePgp+zl8J/2j/Fv/AAUS/wCCz2rab8dPh3pHxT+E/wAJfB37Tmk+I/jh4o8G3HgOx+KP\
jDUh4OtvDAsrLTfCHw6u5tY8WatPq0WiaRZ2LeZqUlzc6fBffhWVZNl2U47imo8tqZbnmR04whUq4mO\
EnlsKdZ+xqOlUw2Ek61Ss4KphnKc6+Elh6dSEY4pwl/aHEHjTnHjLwv4Q5Zl3HMeK/DzizOsVh86yiP\
C2ZY+XFWa1spw1TM8rqutmWa18LgMJk9eWLwOdfVKGFwObf2lmuWYrELJaOMpfupoWk/ssfteeDPA/x\
+8P+Efgz8efDPizwzbS+DfHuueB/DXime+8NR3uoPJoIuvE2ive6Dc2WuS6xDd6XdR291pWqRX1lfWl\
repeQr+Rf/BXX/gj38LP2ifhp4Z/aH/ZY+G+hfDn9q/9nC7tPFnw4/4VV4X0rwunxE0C0k1S31/wFrl\
t4XhtLp7VtJ8R+ILl4LJLx9X+zDStS0HxOp07TIfjj/gnJ/wVm/YR/ZeHj34SeIvjB+11d/DLx98WPH\
Pj/wABXHxP+CHwo8JfCz9nzw3rn9reJT4P0Pwn+z1401nULY6jr8863Ufh3QbHwuNR1C3udI8H+E4Jt\
dvL77G8c/8ABdXwtp3xt+IXg74AfAzTP2pPgr8NviRpfgDxJ8SPgb+0V4F8S/FjWriCx8MT+P8AX/An\
7M8vhSbxJ4303Tb/AFbxBa6bf2lyPDviJfBd/qVj4hi0y21G80/9Yy7xC4LznhynWzPNKVDMMclhMVS\
wfta1aNWtFxdvqDxGJp0arjzUa/NyQcoUp1lXtFf5weI30CfETw28ZeIXk/g/gsZw7h51Mdluc8Y5dk\
OWZZnGW1cRh8LDLsfX4xoZVlGcZhUeMo5dmGQVKVStmd606OWV8tqxnL4V+MPw58A/8FUf+CMuo2X7F\
eufHXwF8bvg/c+CNf8Aj/8AsofDT4wfHrSNYs/GGlJrg+IngTTPhHr3x1v7SLQT4vvtd8beF0kt/Ek+\
sap8Lk0IWFz4wh1Ky0z+UL4j/s06Z8KPiV48t/hL8ev2m/EHwZ8Q+LPGN58EPGvxPufD+tX/AMRPg/o\
HxA8ZeD/BnjnTT4/+EcBC3Y8P6lb38tnp+nodU0i8srm1t7rT5LS1/srkvPiHYfErQf8AgrT/AMEfLH\
Wfj38MPj82syftxfss3d5Emv8AiLxdp02kXlt4ev8Aw/p+tXd1pPxoi1PxZqDadd2+m36aLDqP9sR+I\
r74Z3lpomoeKftEax4k/bx8X2N5+1F/wQK/bE+FGr6lI0eu/tI/s+eJfCF98dNPjgsNCt7CTUNF1fwf\
o+k/FWE2vhLw/oyjxNNfyaHot5fS6AsN4Ehn/P8AjDhfNOIcuprJ8yjiMROlh4UZf2dWxeXZhQpuVTD\
16NWlh8bRwc5wq8mKo1YUqU8VRhiIyoUU51/7U+iR4i+DH0ac5fDOZ+FmC8OeB8lxua1q+WZbxLk/B3\
EvBGZ4qlhcFm2S4vJauYcJ4nPcHha2XKvkOYZdUxmMwmQY/EZNXpZpj5U8Nln8nfxF8PftFz+MV8L/A\
Bh8d6b4x/4Vr4Y8S/Bi9+H/AMdfglb2XjPTINJ8Oan4J8PaL8Rde+HPiDwTreq+KfAOvOJ/DH29obrS\
F8IaJ4U1ZNV8I6BY+HIf6tf+CNXxG/by/Zfl13/gkb4rtP2Z/BH7QfwMl8UfECx0n4z+NPirqs/i/wA\
G+Mbbwp8Q9Pg8HS+DPjF4h0ZNTttD8cxz3Gg+FI4LGwtNJuNW1S3TVb++1HVfx/8Ai5ov7F3wf+NHhm\
/+E/7PP7efxT0HwD4wfwv8Z/2b/wBrP4P6z4Si19dJuvFWkeODpPx1/Zt8RWl/4c1y2uE0ODS7NPD1z\
b2+o6dPqeoajq2nqfDt3037W37T/wCy14h8IfBz4jeGPjT/AMFIvBn7dnwruNE8d/Dvxj+1nq/wC+IV\
94TtvEUFtYeLfDnhn4z6tZ6H47Xwxp+pWeoXnhqXUdHudLstRtdWmsvCnh/WfEeqavY/LcI5nxFwXjc\
wxXE2H9hQoShTth8Hh8PVlh7Xqzp4iGCw3t8VdUVTTxDqyhQr4erh4qth6tP9y+lt4P8Ag99MHgDh7g\
PwV45zXJ82z+lPG/2lDjLOcTPA5zTxFF5fhKuAr8S5/HKshnBZmsx/4RnltKrnGXZpgM3nWy/NcJif7\
Sv2ufhZ8a/2iv2dfif8F/iB+zh4C8e+EvHmkabpuo+Gfhz+1t4i0DxvJd2XiPRda0LXvDGr+Of2dNP0\
m11fRvEGl6XrES6jdGyuP7Da2u7PU4Jn0278A/Yo/bg/ap1mfxn+zN+2H+zN8Q9D/bC+ClxPc61F4U8\
Q/s4w6P8AHX4J3WqR6Z8Of2oPCVhqXxh0ezOj65iSw8S2fh+S+sPDfii1msrx9Hl1C00W1/ll8UfE/w\
CBfx7+B2lan8Z/+DgnxR4g+MUvw1sdZ0f4Y/Fz9nb40a3o/wAMvinqNp4b8Uar4Ktvi/8AD2O4uLLTP\
+Ei0K10LVta07TNSs7zTTNdpoephLW3Hyb8KD+1L8ePgV4S/aV03/grf4d+EuofsYah468KfCD4b/EH\
9p/xJbftC2kt74c8I2+uaf8ACvR59E1hta8B6yklr4ctpLrUrXQ1tdF1HS9XkstC027lh/T8b4hZdhs\
0wubYeFdzr4eCxFX2mXYhPB0pVKsqddYStXVGrSVWVbDTxEakozdbDQp0I18RVX+d/C30DfFzEcGcY8\
IcVePOOrZNlmLqPK8vrZVSyqll/EOIhh6CznJ8TxD4f5TWzPDZpDCUMo4ioYLHU8tWBw+VZ3KpjMTlO\
XYbEf07/Dv9mf8Abq/4KRfsOeN4tY/4Kp/E2XWPG+h/ED4X/Ev9n/47/sY/sNzSfCz45+Crm50m/wDh\
18UI/BfwesdY8K3eleN9M0bVrG8jttF8V2un3mk+ILWz0XU5LSG1/CL/AIKq/wDBLX/gpD+178ZPHX/\
C+T/wSWvP2uvhj8Kvh5fab8RfhpdftI/CT9o39rb4cWkVtpfhD4ta/wDDm8g1r4b+Ib86z4Q8aeDdUm\
1Wz0VtNOnw6XftYeFrn4ezXH9bH7Wdlq/7HHxf1z/gpH8MNA8U+L/CkHw98P8Aw7/bF+CHhzw14giv/\
iF8JtB8QQTaJ8fvCA0PS4LbVvjj8PtOvr0TXHi5rjTbj4eWup6bBrfhNdON3efKnx98a33/AAUU/wCF\
TeMfgja+BvA3xw+EGsPD8Jtb8af2d8RdA8CfEHX7fT7f4oafrPiHwO6zat8G/F3w7uba2Gq2Utxb33h\
LV9E+IWiWgu/7FeD9byXjvi3hytVyGhioYfPKeV4jL8XTpZfhaMs/yTEygqn1qvRw8J42VWdJ1MPgcw\
xOJpYbGUsSqNOFOdTFP8q4myXhnMsDlXEmTTnlXhHxpmGJrZJOOLqJcDcWuGEnissxMW3WrYTC0v7Mp\
YzOaOFjicyyaWV5ip18yy2WUU/4cf2HP2N/gf8AFXxFpP7O/wAVfgZ+0N8Kv2iJ/Elt8K/AHjf4Qfte\
+A/hT4H0z9prwR4j0jTvBt/8Tvh9+0d8LbjXPg1f+Lb7w5p0Mcui+MXuNZ+IK6F4W0XS/C6eM/CEGif\
bH/BT7wzFp/7TXiz9m/wj+0/+1D8XPgr+ynqVx8JPhbcfFf4v+LPF2teF9Q0vS/D1n8UfDkA8RaJZW8\
EWnfEjSNd0eC4sdNtobjS/CelW8M9/pljpc4/bT/grZ+xR4C/a2/Z4uP28/wBn3whDrHxJ+Fnh2X4Jf\
t0/sveH9e/4WlD4fm+E2kWGkeOPBms6xo9zb6vceO/AHiLwZpdlpeoaVC1rqFtNZeOtBbR7a9fxm/xb\
8IPh/wDFD/grL8IviB4L+F3jGwtP2qvhvonwh8X/ABI0r4mfEmw8QW3/AAUK+FfwC+Hfjn4Sfs+/tEe\
FfGfieW713w7+1f4b8KeLdP8ABfxe0u4aw8A6lr/xU8LeOW1bRbTxPo6Xf4/4l4HN+K+Gq+GyOpGPEO\
AnLMoeyk6Us+ymShTbhTxubyli82y/FV8JQxeW4XL4cuV4Whm2HoxeEx8T+8foU594VeEviHguJ/E/C\
xwnCEcto8IZms1WHnQ4E4tpY9VvrOJzXA5DCpgso4iy153WyHM8PmEoVcZisxyXO8XiKOI/tyn+Evh3\
4R6N4hTX9C8RfGDxT4UspPCXi/XrHUvFOkp8RtJ1Lxl4N8Ia/wCLfh54LudHgshcWVn4k8e6R4e8Pya\
grm10seJRquo295ZafPayfO/7Jvw91Txt+1H8KPgLdNrPw+0v4neOJdE0T4j+GvEPh34It8OJ7+XUtO\
1HxFf+KfCHgLWbW3+GWi6lrPiW+1F7uxunufDx2q2nQ38N/Z/o3+1t+zl8Yv2TvEniLw58Ufhf8XPh9\
Y3Hirxv4S+HniH4nfD+68BP49s/CerLpl3rWgXWnatq+iay0VleaTd3D+H/ABBr+lRHVLb7HrV/a3Np\
e3X6j/8ABJP/AIJRaz+39+zb+1p+05qvxLfQ/jo/jW28Ffs3+P8AW9e1/UrvQPjJoEvh/wCJvxO8cfE\
aOGwkn1e11/RPE2i+Gku57nWYFtfGHim91fwvrUsOkxzfhvh9DOMVi8dw9mOS/Wq9WpOdSlKlTp4i9K\
ip1Hy1V7CrKNOmoUKVamqOIdWVKvUdCVo/339NbBeFa4GyfxH4f8SY5RwzXyyOXQxccTVzLJauGzjG1\
MFSo1Y0I18VQwuIxGNq1s3xeGqYjF5bTwNLGZfl8sfSlGt/Sb/wQ0+DuofAH9j/AMc+CfFvjrX/AIm+\
Nrz9qb9oXWfFnxd1nXE8TeG/i1cWfi2Dwf4V+IHw/wDGcvhrSZvHGg33w08K+AzqusT2im/8YQ+KHtj\
9jjt0jrf8FDv+CwF3/wAE8viVoHgzxt+yt4t8eeFvHMtuvw5+IOhfETTtJ0jxbBbaLZX/AIqlP23whN\
ZaTf6RqdxcW0+lPqcmtz28Eeq22mSadMZo+x/4JU/tza1+034E8Yfs5/Haxs/Cf7ZH7Ij6f8Mfjx4cl\
8SWOuXWt+IPCN3qHgnU/HWkST+KdUvPENqPE/hq+h1HVYrzUtOurm9tp/7SS9v7zRdJ+tv22f2O/hr+\
3n+zt4x/Z5+KdzqGiw6qRqnhvxVoXk3GreAfHljp2pWfhrxvpdhfg22p3NoNUupI4blDt88y2s1lqUF\
pf2n9jUqVOpw0o8KVqWGm6D+rVJQjUpRqPVSnRh7Ja1OZVIRcFTm2uVWUD/nOxOJqYHxhpVPpAYDM+I\
6eCzChT4gowxn1XM8VhaUKdFyoY6pQxScpYWNKrh8Q6NWOKoqnOFTlrKuvztvf+C4vgj4T+CB45/at/\
YX/AG/f2WtPl12Lw9JqHjf4BXF74J1rxDqEuvT6VZ+DfFr6xY3Ou6hNoGhC8uLS70fTLmJTO8EN1BZX\
l2n8/X/BWv8A4LIfD79tXXfCXhH4LeHPjB4e+FPgbwkdW8MeJdS8At4I+IFz8X9a8S2UXiLUdX1PStN\
8Q6lf/CWL4eabLp1v4eguvCF1d+I79df1ZtY03RPDsFz/AEAf8Epv21PHt94h8df8E6f269dew/be+A\
eqTab4WvPF2jPouqfHj4Ow+GdN1nQfE2m+JLvV7keP/HljZLrjahdQkvqek6Umq2WpeLpNN8T+Ja/kA\
+PP7M3xH+Hev+G9O+MfxG0if9qT4kfG74r+Cvi/8KvH/iiPRPG3wx8R6Ve/DjUNA8dfF74l/EPWrTTL\
zSPGkvxI1DWrDxVHfXXhK80fT/7ZTxZfSvrVrof4J4rcV8T0+FsDRw2MdWljZ1KONdGlHCYzC1cPPD0\
3hKtWGMxNKderUxEXGlQoqdTD0nXpuVFTqn+tf0CPAPwHzHx44mzXOcgWCzLhPB4DH8MxzPG1M/4dz/\
AZvQzXFUuIsBgMRkOTY/D5bgcHlFWlWxuaZjPD4TNcbSyvFxo5lUoYF6n7MH/BWS9/Z38SeEtE8Y+Dv\
2av2kPh/p1jAL7wf8Y/g/8ADjV9bvdD8Q6vp/jjVJrf48weDjrtr43XS5tR0+xbxBqeu2Whtqjafc+H\
ppdPtbC0/Sj9pPwN/wAE4P22/hXef8FRP2W/gh4st/HHwm0r4W6d+3X+y18GtVuPAo/4RrWX8WeE/C2\
r+Cr+w0iDwz8QPHTX/hO+0fRJtH06+ub+31fSL/WNJ0O+stR0q6/G3w7/AG/Y6H4g+A2m/CzwD8TfGX\
xl1f4K6t4J8QaHFcfEH4r+Ftdms7zUfDXhj4Vaz8OPFUkJ1bX9P+IyaV4j8L6jaatMNSsrOwvNL03xT\
oFudP8AoP8A4J//AB18b/sXftFePvin8FPgC3jz4YftPaV8S/gH4X8E/Efw74s+NWpeMNd8XeMPhNrd\
78L7VPD1z4W0b4ieJIdGPgiDU4tP022ur2f4hw+fosVhqOj2dj8DwXxusVVocN8R5pWxXC+LUIVqGZ1\
KmLlQlTr8sYU8QsLScXSaw85UJqth6tKpLCump1E6f9PfSz+iI6nD2a+Kvg3wvh+C/HjIqv1vK878Oo\
UuFamPhUwlLGTxGJy6Ge46NejmD/tbDyx1J4PMqNfCrMquIxOX0K+Hxv8AXB8Qv+C12n+G/D91qsX/A\
ATf/wCCk9z4fuR4ss9F+Mlh8MP2a/F37Oel6t4TvpNDvdd8XfH7wN+1te+E/CXgS118Ok+u3+t2WkyQ\
6feSW2oSxwSuv80n7Mv/AAVN/ZB/YB/aP8O/GS98TfHH4b+EvjYLrxlofwJ+JXwS+IVj4q+G/wAKvGn\
ji71zW/Bd54AXTR4QHgLVrTV/Hfij4LeKvh74he9sr/UPE3hPxbo+qWHiKbVtO+FPgT+3/wDt7/DHxf\
4p+G/i2Xxn8Vrb4pfGD4iXOgfsb/CH4jfHvSPj/wDsn/FjwT8SdNtpf2YfCP7O/wAW4tX0vwUlxqyaZ\
LYTXPh7xf8A2/bavrHg298SXfxE8QeINGt/1j/YO+IEHxc+EXxq/bG/aM+Dep/Ar/gnx+1j8P8A4r/B\
j9of4s634fsoLfxr4i+DPgy+17w7+0V8PvgZ4Z1DxXK/xek+Iei+ONQPiK30XU9I0rxV4S16bS9OsL+\
9CQ/6OeN/AFXgnFLIOO/BvE5Rn/CXFOEyPHY3h3OMdQjl2Y46hmWIwNGljcywmf0KmV57PDYPBZVjXg\
pvF0ZQzSH1zBSrRpf8w+QePEvDbOMryjPIxj4ReJOIp4HPsxzHB/WsBl+AUMZSwmdVcHTzDJcX/aGW5\
hOl9UlRxX1H2uJr4XF4uGC+u3+zvEf/AAW+/Ys+I/8AwUc+Bw/Yb+PX7Ifhb4b/ALUXwx8beHP2uP2o\
f2gPh78WvC/h3SPEPwZ8K6/4r+Bd58RPB/xY0j4WWf8AaVvZ22veFdC1qx8fT3Oqf8LIuNH8S6NEPCn\
gcXvxx8Qv+CNfwS+PfjTWPiF/wTb/AG9/2Evjd+158Ptd1b4//D7wR8Bfivrfww8Q+Bx4bTU5rGfwl4\
s+Hf7S/wARNb8KaE/jzX/BWlahK0WkTX6+Ihql34203xNBY6s3zt+wh8DP2pvg9Zt8Rv2j7P8AYB/aA\
m/4KuzfDD9rFtA/4KQaP8TP2hdO+Emh6G/xe0j9n/4i+LPElvpmqafp2seJ/C/xS8YkamdQ1K70bT9Q\
t7fXLPwhEdURrP8AwVH/AGjvgJ+z38fde+H/AMKv+CQP/BLf9oL4V+JPgF4Q8E/HbXf2YfhvaftK6D8\
FPHfjrWfi7cfDLSbD4w/CD4ffDC++Avxm13wPaeONSurWO3HiGTR/DPhrxFoOrIumzRp9RxnlP0XOIM\
2zrw14a4G444T8SvB7CxwXFTwWZ4LirLHn+Exbp8Q57SpYVrB4jC08bj3lWHpZbRwuW5pg6OFxs6k8X\
mOYVp/09mGZeMPh9wrk/E9Ljng/jHg7P6FHDYOrWrZDlWbVcpw+Kw/9g0cwzDNJZXm9B4f6vg8XgFXz\
eeI4ep5fhqM55bh8pwlKjzXj79kf9vz/AIKd6Fb6n4C+K/7Q9kvgvxP4+8HeIv2Mv2rv21Lv9oj4pfC\
r9o/4d674q0Lxj4LnvdW/Zm0PSPAt0ukJpMemPrEjSvoWo2viTUdeTTdaxa9B4B/ai/4KR/sg+A/jzb\
fDn4kfET4L/Fv4IvoN/wDt4/D7UNE/ZJ+LOnw+ILDxPoPwR8GfG/4UeB/EWv20/wARtR1nWbrS/Dfjv\
WNAGsX17r3hmy8UeLvG/iLWPEEWheHPJf8Agm3+2/8ADv8AYpl8MftNfs0fs8S+H9Q1n4T2vif9p74B\
fD3x14C+LHg74m+A/A3jSz+GngPWfhNd/Fz4rXHxT8L/ABS8O/D74keEJ9csYtOtriDS/HlhrsvhnWv\
Dr3upXP7Pf8FDPiJof7UeleF/2+P2fP2Sf2yPhb8Z/wBnbRv+E3uNB+NX7Hfxon+GH7ZPwe8QeHwfEf\
gvxXq3whv9b8Pax8P5/h9odzo3iKbxDeaCNX8I+PDZRazqekWNx4ev/wCMOPeHsjoZo3kmLxfD2f4KU\
KuHoVKFXKIYj9xRrV/YtwWK+qP286OFVfGTqypOpgHi6eIrV8RH+pvo5eNvH+a4fP8AJPEDgDKuOvCb\
N4LA5vWlisLxpicoqV6kqWErLA186zrA0q9LF4aOIxkqOV1Y4Wvh8HxNiMtzjAZXl2Dxvyh8GIv28fi\
n4z+EX/BTB/G+pfFD4y2k76jOPhb+wH+1DoPi/wCOfhbRdWs/Bnhjwd8SfHf7OPhG9+EvxN8H6Tpule\
IZrXV9E8QjXbvQPFupeHLzxVeactl4ZsP6rj/wUB/ZasvEWo+HvF/xn8I/B7xVpWi6Hr3/AAjv7T3h3\
4h/sgeIdY8PeIb7xFp9jqPhrSP2k/CugT+MtHfUPC+rxNeaUt3DZ3FgYbwwmeIS/wAwv/BLL/gqT8G/\
2Tfj/wCIPhZrHixvDv7IH7SPiSw8ReFNC+IOueItGf8AYf8AG974j8Q6Fqfwm8feOfid4gisL/wxo5S\
yshrt2/2i+8N6Ho93qmo6Fr9pF8MNO/qvH7fP7CpGR+2n+yYQeQR+0b8HsEev/I5V6nCOeYX+xqNfA8\
QZfh6VarV+sUsZCvVrxxMbQxEJ1KuZwqxqOolVnaNNVHUdWVGFSvJn554/+G+f4XxLzPKOLPBjiriDF\
4DA4F5Xi8hqZXgcsrZLiG6+U1sPQyzgitQq4SGFlVwOGisXi3hI4Wnl9HMcThcspRf5M/8ABRiz+EX7\
VF58Pf2h/wBgv9p/4Ja9/wAFFf2fraXU/gNpvwY+Pfw+8e+OPHHhbSW1PxF458D2ngPTvEqz65YnwjP\
4zub+xhstZg1TTmvbPVPC/iYx6XbWPxv+2t+29+yB8d/BvhTwP/wUC/YN/wCCl/wc/alu/gh4F8PeP/\
GnwQ+BS+Dp5LC617wj8RvEnhnwze3/AMVtR074qfBtfip4Nu5NHs/E1l4ig0q5t7u4sBp3iNbm9i/qP\
+J/wj+FHxc0a18OfGD4XfDj4r+D7bWrXX4fDnxL8F+GfHGh6b4kgtb7S7TxHaaT4q066toNTSw1XULf\
7Qkazxw6hOqPsnnV/CNf/wCCdn7BPiXQta8O6j+xn+zFbafr+k6lot9caB8Efh34U12Cz1WzmsbqbRf\
FPhbw/Z6n4a1ZYJ3a21DTry1v7OZUuLO5guI45V9LiDhnMc2ji06OCxFPMKap1U5VKVCvGC9xVcNXoZ\
jCNek5SjHFUqkKrpOEZRkqdLl+L8LfHHgjgCpwxXwmJ4iyCtwni6mLy6tRp0cdmmV1sRUg8UsHneXZx\
whiK+WYuFOFWrkGNwlbAxxixGIpVoSzDH+3/gM8MJ8D7n4YeIbi+/aC1z4P/Ej9njxDqfjz4B/Af45f\
sufFDVPDX7SkGteLJb0fEXxb4f1bxX428PfDX4mavoHgPQ/Dup6HqHheLwVq1p8OvCum3+t6zEfEevW\
P7Ofsq/AL/ggb8bf2T9O8C678efhd4J/a5HwG0mbx98QPjf8AF/4jfDHWvAnxk+IPhnVmn1vw94E8Z+\
NPBnhr4neH/Cnjs3drDa6PBeWMln4d06DWtRuZtSXUtQ8c/wCCkfxk/wCCbEXxkk1X9mX48ftI/An9v\
P4XeLb7wno/7R3iH44/tG/GD4e6h4b1U23hHxBdeJPibovxx8XeIPBmh6h8PdLmfSNWsNLvb6+0SSOL\
/hHNYjk0xbD8zPjh8Tvgh4e+PPhTxR8JtS+MviTxT8XV8UaX+3l8KPGOqfs4eOvCHi/xKy+IX+KMP7P\
v7R3xi1b4haP4r8D3z+P/AIixeE9a8Ryarr4fRbTWNQ8UaxqOtaXq+j/z5V4f4e4J4lhhM0pZRm2VYi\
hLD1FVX12rhpO8VOaq4uiqGIpOFKnVrQoYVLBwVWHPVp4ucP8AW+n4z+Ln0kvA2vxbwdmviD4bcaZLm\
tPOMLiME/8AVbLc0o0qcMVXo06+C4ezJ47IsZQr5hjsFgsbm2eRfEWJll+LnhsFjuH8Liv6ZvFPx8/4\
IUf8FefBfxa8I/tSeGfh58P/ABt4L1zUfgNf6v8Ata+F9B/Zg/a5+Euu/DDVLDxbqfgzwV8Q/Fs1l4m\
8JXfhbxx4iu1v9NsdWkgtbrVr3SfEWnvYazLZ6s34Mft7f8EePhL+xkn/AATh/aq+K37MngDwf4P8C+\
Kfgd4n+GNjba5/wqX4xfDC51TXdJg+K/gDxNo0Fy3jbSvFMZvdUvvFCXVrq2oeKZtW1xltrqe3upf4u\
v2v/wBpnx98Yf2sPHf/AAVZ+AP7L/xUj0X4lWWk/wDC7G8WfsWwXn7KF1aaL8LvBnhHxXqviO61X4j+\
NbDQ/G+l/E3RL+7uNfe606DVrO+g1WW20nVotasfEfhWj/tVfsl/Erx3p/xV0v4V+D/hl4n+DCeD/H3\
hz4R/E5/iF+0R8B/ir8WdC8XWPiCw0bxBHZ+Fb/Wf+FKar4W8KW3h3xt4b1vULmfWxfC9sNZitYtFsv\
Cn94YXKfFHifxM4e8Ls84Z40zzw5xKpQx2W5MqnEDjU+pV3TxVPJYVI4DMK0cHDF4nAV4LCKWS4ytWp\
VJ4fE1YU/8ACujw94dPwj4izqHEtPJPE7h6tKvLC5pTwNGnj6FDEKhUwWAq08TDNcJjnTxFOvOhXwOL\
wmKrYHE4d1sDiKeCWM/v2+D3gb/gjL8Tfgd4r0j9if8Abh8Y/s9+AbvxtJFrHin9nD/goP8AHf4Qato\
vjuxtPCOo6vq9r4S+IXxSm0jWdQu/Cq6Hp19eX3h/UVewnRbaWK9sLeey+FPHX7Ev/BL66+MHx58P+I\
v23ND/AGY/2k9ffWfiT8Jf254P2vNL12L9pHwX4t1HWfEPir4cftDfDD4nfEnVfh98UPDGh/F3xP4Yk\
8ZeGY4fC+o+OrHTtLka20nSpr251D0r4O6x/wAGzf8AwUh/ZA+C/wATfjR8Gf8AgnL+yjq3i5pvFXiT\
4Haz8T/gR+yx8bvhv488Jah4s+H+v+HPEuvfB/xh4O8Ra14OfUYNau9JTURZ2mu6Vd6Lr91oVjefZLe\
wj8Tf8EHv+CGP7YXwT+O3gr/gnLrvwY0b44W3hez07RPjR8Av2vvib8cl+F+p+I5rm80rSPH/AIf0j4\
7a7p8XhvxDZeFvE2mvFq+nXkVxZC/ubW0u7vTQi/pGN8LcF4JVcT4i+H0uNeCOKOB44qhRhPgbKqnD+\
MwmJvg8RgMZj48TVMqxmCx6qqKnDLcRhcdbD0JOvg69RVPNn4u8YeI1TF8OeKvGeM4yyHi2tCeYV8fn\
WMr42VdOjKjicRi6+Ex2Mq0sPKjFypV4YyOGpzxNfDYT65KMj07/AIJKf8E//wBhT9mj45/Hnxw/7cP\
7Bv7ffx//AGnNL8P6F4Xtvh98J/2X/ht4l8OeH/DPhf4iW3xf0DwT4P8Ahl8SfEEV1pfizwzqtnceKY\
NKsNNgvx4Da+11NTeWe4g/Wv4XeIPE/wCy/wDF+w/Z98ZT5/Zj8frb2v7KHxC8R+INQ1nUvCfio29gZ\
v2YfEmu3WnEBgf7dm8FDVbv7S2l6LFodrqmu3u2w0b+B+P/AIJW6B8K/hR8Svidrngn/gpb8Ivjl+z3\
r3hjwzoHxB+B37Sf7Ovxo0r4M/ts+ENR1a7tfGXjTwt8P/C2k+L/AIW/BzxD4zsdRttJ8TWV/q8Xh3V\
dNVYvEPivVbyCys/2y+Bn/BNr9vv/AIKPfs/af4+8af8ABW/9qX4NraeLrzwb8Tv2bfj58AdI+Kviz4\
N/Gz4cWzeE/FNzN4k1rxN4Kjlk1K5vJNesI4fD8Nxomk+Obfw1falrlzp+qajqP5Xn/E+S/SE8Q8VxB\
m/j1wzlPHkMLRqUMdieF894byrF4LLL5FRyejlfDnC2NhRo/UMqw9amqGWYOhGMsJXSqY7DZhSofo3H\
3g5ivCfhSpnOV8PVMZ4dzxNHKK8FxHw5n1eGb1cHLMqWOwVfKMbOjHCwhUjQc6jqSpc1XC15weLo047\
X/BUv9jP4cfs5/tJ+Po/CPgzwt8SPgX+354VsvC3xI/Zj8KapL/ws/wCFHxHnXRfhv8KP2iv2ePhY/w\
ARtJuPHXxe0rx9qMUHhnwzorquv+HPEXjrwla2nhXwzB4p1+5+uf8Agmtonws1/wCLXxc/4J7/APBQ3\
9lf9l/x9+2H+zc2m6bpvxy8SfDv4Z/ES7+PXwybwvoes/Dq6m8S+L/D0l3fa9bfDm9s00fTLTy5bLwp\
4OEN54e8Iw6Vb6bN8d6xa/tVfG2y1/8A4Jr/APBQ3xFLo3/BS79mDV9I+Kv/AATn/bFtfEMHgjwP+0h\
4cifwzoGg+KPA2s6JdaReaZ8Vv7T8I2D3st3eW10fGGu2Gh6j4l0W112PSNV8N+H/AO3J42+Cn7dGn/\
tyfFTwHf8AiDxn4S0H4Z/Aj/gpb8OdUuPAT/ET4T/EHQPDOm/Aay/aY8CWkvgfR4PBfwb17TL/AOH19\
qvmjSr3w54g1C+8KeI7vwhp2v8Ahmy8b/g2dZfl/D/FuEzDEPD1eH+JKlKFR+zVXDSrSo42cqk4yg50\
8WsQ8PdVI03hqcs1eKp061Ovyfvvh3n/ABT4reAOfcFZLmWOn4reDeXYzG5dWw2Pq4XNf7N+v8MUMLg\
6GIhiKNGtkX9kQzehWpKVXFYrNsLwTgMHKdOWBw0/6m/iZ/wS1/4J3/FnQrXw74p/Y++CGlafZ6rDrM\
Vx8M/CNv8ABbXJLuGzvbBIbzxP8HJNB1LUdKMF/OXsLi7lsZJo4LiS3ae2tpYvz8/b8/ZPvv2PP2NPF\
UX7CXgP4+6VpfhPw349kfSfhr+3B+2Z4Xv/AIXaHq+m63qMviv4b/Duy+N/9ipqNr4s1iTVr7Uri01O\
200wyajfeGNdtJ9Un079fPHfxk8Rxfs6a98ePgT8Pl+O2ot8KpPip8NfANr4g1TwZe/E+zfw/F4o0fw\
9pt9c+DdQu9H8QanpD+Xp8EukyyPqE9vZ3SWiyS3EH4LW/wDwW9+Nnxv/AGfrD4j+CP8Agn38D/in4J\
+JWp6d8MJfCsX/AAUD+Eeo+IdE8V/EHTvHNh4b8K/FP4Z+NfhJotx4fh1W98E+KLG2s9Uks118Wxi0h\
tRhvLZ5/WzlcBZDmEMPmOV4bBZvmNGUadWjljr11BSUE41KGFqr93U5H7OcrX5Lx96DPxfg7PPpR8ec\
J43EZD4kZ3m3APCuPw7xeHzLjR4HJ8NjMVCrKg8Xh8yzvA0aSxlOOIpxxFqarJYijTr88akV/CLa+L7\
y313WfjQ2ufH/AMM3Og3fhbS/AfxQ03wXD8Y/EOlfG+8sY5fDvwv+J3xCe58Ea14S1SLxJ4X1+2fVmE\
jaXe/DuK20G11yHS7+U/qr/wAE7v2Iv2qP2ptZ+Lv7Hfh6f4LeCPiBp3gLTfH/AI88RfHjwD4OuPtnh\
3R/Efh/T9J1z9nv4sWXwg8TanpU/wDbvjW4i1q68Lr4ceygudK03WbnUL5WNv4R4W+EHh3w/wDteeK/\
iP4f8B/tF/A/4S/CP42xXF9rHwv1Lw98X/i5+yv+2DplxpWvadazaJpfjDRf+FieDtV8bW/xDsvCepa\
h4n0GXX7LQrrxDBe63P4b8SaHN75+1PqP7YHxBvVt/wBofwf+0b8Af2iPC3wk+Luu+CfiFefDX47DxN\
8UvAcWk2dh8Vpvjn4ih1PUvif4q8LT/BHTdQ8LXts8cPgzSPCnhvxJrNhY32rDxXNN+PZhhsmxeOo5J\
j8PjMZGpKti4clWOGw1WVTmpynTqRkq9PEYimq8VQjgpRxVS9Jxap11D+2/D3xF8WeGOFpeJFDiPg3K\
aWCo4LhnOaNbKpZxxHgVQq0cXlOC+oyqVMrzrJsPWlgcZg80WbUsTg8rwrzChDDY7GZXhMb/AP/Z'
	$begin 'DesignInfo'
		DesignName='main'
		Notes=''
		Factory='HFSS 3D Layout Design'
		IsSolved=false
		'Nominal Setups'[0:]
		'Nominal Setup Types'[0:]
		'Optimetrics Setups'[0:]
		'Optimetrics Experiment Types'[0:]
		Image64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCADIAMgDASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD++/yJf+f25/74s/8A5EpFS8CgG5t2IABZrR9zE\
DBY7bsDJ9gB6AV8rf8ADOXxh/6P4/az/wDCO/YV/wDoLKP+EC/bZ0//AEDR/wBpr9nnU9Jsv9E0vUvH\
37IPjjXPHeoadbfubG+8a614G/a/8L6JrHi2W2SKTUrrR/DXh3Sri8kml0/QtItHh0+38z+1Mb/0IMT\
9+X//ADYff/6mcOf9HY4f/wDCfir/AOho+qCLzDo8dpOjZGS8sAZGUBleIxSg87v4iCCOBVaGe5t3W1\
uE89ypaB45QZJEBPyM06xrLKigbyCGIdTsPzMPmD7Z+3V4W/4l/wDwjn7Jnx287/TP+Eu/4TX4w/sn/\
wBneZ+4/wCEc/4V1/wgPxo/tryfs/2r+2v+EpsPtP8Aa/2H+wLX+zf7R1XD1j4q/tqeGbnQLrxD+x38\
PfG3hy91iWw1xP2ef2r9O8YfEjw5bf2Frd/YeIbXwr+0H8E/hXoGuaOdcsdJ068jXxdb38UXiD7Vb2V\
7HbzxBrPMLBcmJwOKozbSlFYLF1eWTaS9/DU61KSTd5OlOULXbkuW8dKfhpnGMk55XxDw9mGDlGc6de\
XEuRZeqsIQc2/q2cY/LsfRk1FqFHFYTD4ic7QhSlKcFL7G+0SDlrS5VRyWzbPtHc7I7hmbA7KCx6AE8\
Ufa4v7lz/4BXn/xivjjWP2rfip4f0HXPEGpfsBftkXNt4a0nUNX1a08Paj+xr4p12W30uxmv7qLQvCv\
hr9sC81TxLqUkMEgtLHTrO7vr6Vkt7O3nuJEibd/4bT+D3/QnftZ/wDiA/7dX/0OVS89yiE5QxOI+oT\
STSxMamEck+sFioU3UWmrhdRur2urj8KPECrSp4jKuHpcU0JylCU8jxGEz+NGcFBuOJlkuIx6wspKad\
OOJdJ1UpukpqnU5fqr7Zad7mBT3V5UR1PdXRyCjA9QQCCMEZpknkXYDwSwyT258yF0lB8uQg4WRoySI\
X2lXH8S5xyAR8sf8N3/ALG9n/o3iz9pL4S/CzxBH/x/+A/jn4rsfgF8U9C3/vLX/hKPhL8am0HxN4T+\
1WTW15Zf2npNp9v07UbTU7Pz9PvLS5m774cftJ/sy/G3X7rwx8Ivj78Cfi74o0/R59evvD3w4+Knw/8\
AH2v2OgWl7Y6fc6zdaT4Y127uLbR4tR1bTIHuHjWFJtSgiZw80attQzrJq1WFLD5pQq1pu0YwxFKcpP\
soKV5XV9F0Z5+YeG/iJlOCxGY5rwFnWW5dg489WviMqx1GjSgrXnUq1KEYQim170pJarU9vglM0e5kM\
UgJSWJirNHIvVSVPIIwVP8AErK2MEVNWXc2MMbR3MFtlosiSO3d7d2iYEM8QhK7pxngZG5SynJ24s/Z\
YXTKS3OHXKyJe3TcMPldCZiDwQRkEexFenKNPSSk0pdLLR9vibt2b3+8+LV+q/r7i3RVbyJf+f25/wC\
+LP8A+RKPLul4W4iZR0M1sXkPc7minjU89MIOMZyckzyr/n4v/Jv/AJEPkMn3W8hugx8nAF1EEL5UfK\
tygUZDrlQ55zGnqig21ZWUMpDKwDKykFWUjIII6giq/wDpi/8APtNn/rra7cf9/t+c/wCzjHfPFNJbm\
zkWKaNGhmdhbrHLlom4ItleSGNCCWPlqSuFQqCxCqb5HUVk05RXdK6Xk7O67votNlcv+Jq0VW8+X/ny\
uf8Avuz/APkukW8jKgmO6UkAlWs7rcpIyVO2EjI9iR6E1HJLoub0s/yuF0WWVWUqwDKwKsrAFWUjBBB\
6giqkG63k+ylT5OCbWUuXyo+ZrZyxyHXLFBzmNPVGJcL20JYNOkbKcMk5NvICVDDMc4VsbWGDjBzSOb\
S9UwiaKRhiRTDMhliZSNs0ZQkowYjB98HIJBpRkk1OLUHvo9Oz6d+vR/MN9nqW6Kr28skiskyCOeIhZ\
FU5RgRlZosnJhbBxnkFWU8qasVnJOLae6GFQzxGaMqrmKQEPFKoVmjkXowDDkEZDD+JWZc4JqaihNpp\
rdAV7ecShkYgTwkR3CAMu2QD7yq3JhbG5D3U+oIFiqtwkistzCTuiB82IJv+0QA7mjAHJmX5jHzgMxU\
8OanjljmjWWJg8bjKsOhHTv0IOQQeQRg81UkrKcV7r/B9vnuvLzTEPoooqBn4ZQ/8ENfAOlO9h8O/2+\
v+Cjf7OeiD9/L4M/ZC+I37Mn7Gnw01q/Y+XL4r1v4Yfsp/sneDfD+v+PZbOPTrO91++0y41q6sdF0uw\
uNQlsNN0y3tfzg1f4R/8FkJP2g/2yfgb+wt+1p8N/D3j/8AZK8P/CKTW/HPjjxl+218UNY+KsPxm+Hc\
XxR0bwR4R+EH7eP7ZXx2+Huh3sk+hX+nnVZR4a1mC8t9Nkh8X6boF94l0i/+z/Hn7Vn/AAW71PXfjT+\
z18Lv2aP2SfiF8cPhTY2Ca/8AGD4W+Mb7TfAHgub4r+AbHWvhZPpfgn48fEjQL3xHrGnXdv4hvNS8ye\
fTtRRrXTza2ItZLzU/5gLvwB+3NffFnwL+1Z4g8F/GBfjj4P1HxD8Bf2qPil8NPiFr3jD9pzWvFWraJ\
4uS2ufEfwVsNZufEsngvR/D0h8FyRaza6Xp+o+FvhrpHhO48Y6d41ju/FM/d4k/TQ8Zsyw2UcOy4oxU\
1m9WpPE4DE8P5dQnjaWFp+0eHpPFcPYrB4mlCo6OLxfK6tF0cO8LWjUpYtxf9jeD30ZsrweZ8WVeI5+\
HnGtPHZLXp8P1q/iNks8PDNlj8urQqVcnyjijAcTTljsvo5jk1ClWwmEngq2ZQziSp/2bGrH9dfEf7d\
f/AAVE/Zt0C68Q/Fr9qTxN44vNO+IXhfTvC3iH446b+yx+zl4D1Xw1q+geA7e18U/FH4IfAn9gT4qP4\
z8GQfFOf4iw6/4N+G37Q3/C3rrwP4dOv6Po2i20eoeJNG/SD4T/ALSX/BbL4gfDjwh8XLLSf2B/jz8O\
fibpMetfDvxT+wx8HfFPxes4rO1lltdah+J1v+2P/wAFHP2d7jwVqyag0dnbafpUPie/gv8ARNdsPEt\
t4XvdNs4NW/DXwh/wVM8Z/Cqz0v4d/tWfBbx1b3HibUNFuL34M+OPBlra6T4v8Dx6BHoV9qeoa18V9T\
h1C48KPqkXxIjt7XWPAXj2+ksYbmw1LWdca6vL2P8AQn9lj/go5/wTz/Zi/bf+Jmq/Bn41+KfhX+wv8\
ef2fbH4s+JvhJqPw6+Il74P+Gv7Zl9460fTdU8N+CfBWg+AL668Exj4Y2lzLfDRZbrwvLPMmn2mpTab\
o3hjTdH8jhD6YVLJq+EynPeB+Bs7oVJ8lWeecM5dg81w7q1KypV5Vcvq4LLa+EUqTpTpSw2FzDDwdOv\
iKKhUhGX6DnP0J+OuOOE+K8blXghxZwj4kcOUZ5jhcTw7HEcR8DcSYLD08DSrZbllbAUMfXwWc1FVeY\
ZfKnmOZYXMYLEYWUMNV5cRH79l/bz/AOCs/g1ll+JX/BID+y/BWgf8S/X/AI5j9qbRdeOvxQBtP03xP\
/wyj+yH8Mvj38Q/DTa3rT6eU0Dw+fiP/wAIqddP9reJ77QdM1XxUsqf8Fk/H3hNRp/xF/4Je/8ABRjx\
5rVxm+s9Z/Y//ZS/ab+K/wAM4NJkJtodO1vxH+1b+z/8BvEVn45S9tb+S6srLwhqWix2F3pk9v4kvL6\
41LS9H++vD/8AwUV/YH8TaDoniTTv2zf2Y7XT/EGladrFhb+IvjZ8PfCOvQWmqWkV7bQa14V8V6/Zap\
4b1ZYZkW4sNRs7W+tJVe3u7aGeOSNed8e/8FK/2FPhto0ninUP2mfh14u8PC0167uX+DUms/H+8tJfD\
1paajqUU2lfAvS/EV3b6hJaahbG2sWtxeahI5GnwXMi3AT95oeNXgTna9vmXgBw9HHxg5P+weJ+JMDh\
alOK55V6mGx+bZ9ONZuU3OWGxGFwMaSpU6OCouE51v4Szzww8TeFaFbEcQ5BnnD+Ew9RUqlTM8nrYeN\
Oq5OKpSqVcLhoxneLioTvUclK7b0XxBdf8HDH/BOvwbbzaz8c/HNt8C/BqTWemW/jK6+NX7G37S1vc+\
JtVTULrRfDM3gj9g39qT4t+LtEmvNK0LxTdQ6rqnhyx8OIvhi4tLnW4NTutLsNQ9Fg/b+/4JLftxeFd\
C+IWq+Gn/aO+FnhG91Ozs/jP8R/+CfP7TPjD4F/C6LVtO8O634q1rxN8cfiL+zQ/hL4Q+E4vDv/AAjO\
q+INa1fWdJ0jTtHtbbV9avbbTLdbuP8An6+Fn/BTH9mrXP2l/HV38T/2IPht+0v4D/bN+JHir4+fCn9\
pn9pqx8HeKvHPgv4e+KDNrmgy6npPi34c6nNovwB8I/AG2+HsD+HYteFz4Om+HviPWNXvdL8KeItFPh\
/0zQv+CfH7IP7Sfxf8NeKfgj4E+EJ8f+NPF2ifGDWvg14z+EXhXVPBXia2u9G8V2GneOfBviK9+HGsW\
nhvwLLf+JdDc3Hhd/HPwjktvg/4fHiT4ZeMfD2n6Pp19+J0vFbwa4rzynRzjwqzHhnKMZiZUp5Zg8+k\
sbToxiqlCNLA8S5DbHY/lisVXpLNaCVFxlRw8JU/3n9C/wDEK+GOBnkuYYTxjznIM3zrLsJjMj4mWQz\
wvD2KqYhVaeYQjmeW5vWzXCQpv6xlUFPLIVI4uhXeZLA4arNYf9lta8Wf8G+esWcNva/F7/glb4L1Cy\
1bQNf0fxd8J/jr+zV8F/iP4a13wvrum+JdB1rwh8UPhH420TxH4O1a21nSbGVbnS9Us5mSN4JHe3mmi\
k+0PC/7Kn7PXi7w/wCG/F/gr4n/ALSvi3wJ4z0PSPE3hHxb4V/4KHftsa54Y8QaB4gsINV0LXvD+taT\
+0nJaaz4e1DTLq0ubK8tZZYLlLxJYpHjmjavy5/YF/Zx/ZU8W+MfHXwE+I/wmm/ZU/bp+Efwg+By/tH\
eGP2Nfjd8Tf2F9G+Jml3Nj4h13w/4i8XfCz9h/wCOnh7wp438Z6Nf+N72TUNc0wa5py6T8VPClw194X\
1LXLz4ZeBfQNY/4Nuv+CVNtfeGdf8AhL8Gtd+B/i/wxrdzqsPiXR/Elr8fLHWtPvvDPiLwzf8AhjxN8\
Lv22ND+KfgbXtEkj8QLfRyz+FTqdjqeg6de6bqNnLbv5v7Dk3Dn0KuL8EsRlXEPGHBGIrRUI1cy4S4e\
zigsRTp1Y18LmEcDnuWY3LvqeNj7CVXD4fN6koyqT+pU3H2dT4DxC4l+kn4Z8S4zg3iXxEzLHTy/2eK\
w1bB8SZvPAY7BY+hQxOBzfKq85Oni8Bm2XywuMweJUaPt8LOg58sk4Q/S7/hmr4k2f+ieHf23/wBrPw\
54ftf9G0Lw99j/AGUPGn9haPB+60zRv+Ex+KP7LGveJvFn2WyWCD+0/EWu61rt/wCR9q1fVtR1CW4vJ\
smH4Nfth+FNd1K48E/tqaT428M6npOiwjSP2nP2Y/A/xC13QNd068199U1Lwx4i/Zs8ZfBu3i0nUNP1\
HQ4prLVtL1iaCbw6J7XUIUu57cfmHd/8EDPC/hvTPiZB+z5/wUY/4KN/st6942+3+IdO0X9n/wCJnwY\
+APwAtPiGPBmjeC9C8dar+zh+y38DPh34f1CVLPwt4SGuQ6V/YGoa4mkbrjWIL26Oor0tx/wTC/4KMa\
B4l0nxX8FP+CuuufAvVLPQ/EPh7W7W3+DX7T/7UHhrxdYa9f8AhjUre41bwZ/wUB/4KSfGHR9C1zTbj\
wyV07VPD9hompJb+ItUtLq7u7W6EMXoVPBL6PmJdKll30pKeCrzjJ05ZjkPGuDwdKpChCdsRLKo5xXh\
h6lSU8Ph3hsDi580I1K+GwsGpQ+Lp+L3HdONb23DGSYqVaKjUqVOHOEMViJ/vIzc3WxWUe1lXk4KVWt\
KsqtRSqRlVqKrUU/0X1LTP+Cg/hq80DVNI8a/sbfGjT01aaHxT4I1L4YfG39mO8n0KbQtaFvqWgfFO1\
+LvxcS01a38TDw6z2Vx4OmhvLB71F1CxuFgkbTl8Xft0SxtG37Of7JoDDG5f20/jAGRhyroT+wMdrqw\
BU9ioPavy5/4Z7/AODgHwroH2XQf20Pgd8VfiJ4c8c/btG8efE7xb8JfA3wX+JHgvR/iV/amnad8Q/2\
Y/hv/wAEoZPFXg/+2PhVbw6Tq1loHx4ku9P1bUbjU9K8SNDDBanct/ih/wAHA/hHxLq2hfFP4Kfsc+M\
9LOh+HtW8L+M/2OvhCPi94aub++v/ABPZ+JPDHjK1/az/AOCofwA1jwxrmn2+l+GruCTTNJ8Q6bf2/i\
oqdRtLqwntnJfRljS+sVMq+kjwLVwtKc3FriWd6lOMqNOniKUM5yaONUK/tFKGGnGniqUYVp4nB4Zxm\
OfirhcbGg898J8pzfHUo8nt1l+MytuPNOahPD8OZplOXylTcpR9u8I6048kJV6sYU1H9JIP2kvjFk28\
37Bf7WL3MS7nI8X/ALC8YkjLEJMqn9tLByMBtpIV8jjiqWm/tp+G7a81/RfiR+z7+2T8J/E3h/VodNl\
0LUv2V/ix8ZLPVbO60LRdetNf0D4g/spaJ8Q/COs6S6ay1o6Q+IWv7W/0e9tb6ytXhXzPzFtP+CjX/B\
XzwFpPwzh/aK/4Iy/8IdLq7WHhfxh8XvAX7T+tfGzwVZ+MrfwXrOvalrN18EP2Ov2cvjV8RfB3gLVdW\
8N3lpYsdN1+10m813SbDV9fYyrqMj73/gul4p+F2kfEnVv2hv8Aglr/AMFGdL0P4cG/12/+Kv7P37OH\
xm8f/AJ/hzpXgrRfFeueM9Z8dftSfCn4H+IfBr6ReT+KrPWYdW8G2thZx+E21K31i+sLpJYtp/RA8f6\
1eMuGnlXGlGb9yvlXEvBef4Gveu8MqdCtkmbxUsTKq4yjhPbLF0qTVSthI05Kamn4jeG2JhVoZ54aUc\
soyj7lTK8bnuXY2nUUoSvKedVc/wALKg6aqQnH6hGcpShKniYckoVP03m/4KAfsm6Prum+HfiD8StW+\
Beoa3pOta1oFx+058KvjF+yvoXiWz8OXmgWOuw+GPFP7R3gDwtpnibVrWfxRoTTafYXlxfrDfi4+zfZ\
45ZY+o0T9tP9izxjruh+FvDn7Wf7L3inxN4j1bTtA8N+HdE+PHwo1zXdd13WryDTtJ0XQ9IsPFUtxqm\
rXeoXFtBb21vG80800cUSO7Kp/MC4/wCDi3/gnP4R8S6ToXxr8T658GNL8QaH4h1bRPGdv48/Zg/ao8\
NXN/4bv/DFnceGNWtf+Cf37Rnxg1jwTrl1b+Jxd6dJ4g0nSdNv7fw/qi2uoyXVmbZ/su3/AOCj37C/x\
S+HsGreLdb8faR8Afib4MiuLv4q/tE/si/tSfBn9lTxD8PfHeiL/Zk/iz47/tA/AvQvh7beDPEmmatZ\
WOmNq2uxWPiK48S2Gk6cb+91WxtLr5XPfo3/AEluF6OEx+beGeavLMxb+q4zDZBmGKy/EuDcalOhmeC\
xWLwNarCcKkKsaVWpUoSTjUpKUGpbx4n8E8WqdHD8P55hK0Y2qznxNldaUJSlJxqxwr4Wwk3CNOULUZ\
V4OrKMmsTSjUSp/oJcWEG1ZYLaHzoSWRExAJARh1LxgbX25KNwUdVYEDOZY4IZY1kVroBhna15dhkYc\
MjgXB2urAhh2Kkdq/Hb/hYP/Bvd/wBDv/wRq/8ACl/Yk/8Ak2vtaT9ij4HafIF0S9/aE8JaCrGK08Kf\
D/8AbH/a++HPgXwpYqdtjpHgv4f+Bfjpp2ieCPCFlbeXbWWkaRY2Ol6XY2lvaadZ2tnbRwL+fZ3w54k\
8MrCR4l4LrcOyxvP9X+vPH4T23suR1VS+sZZT9p7P2lNy5L8rqQ5rc8TelhPCWtf2HHGe1lG1+XhvLJ\
Wvtfl4tdr269vI+tvs8g4W7uVUcBcWz7R2G+S3ZmwO7EsepJPNHl3K8Jcqw65uLcO+fQGCSIBcY4Kk5\
J5IwB8fw/sfXnhrXdS1f4V/taftk/C3T9Z0nRdN1XwtN8XdC/aF0Ke80O81+6h1/Tbj9szwF8TNT8Ka\
tcQa+be9TRdR02wvIdG09riye4thO2RPr/xC/ZW8d+EZ/i78a/i1+0B8HPjb4t+HXwa0TX/F3gD4Zr4\
i+B3xk8Tax4i03whqPiKb4A/BPw3aXfwl8a6vq/hbwy+p6rEknhjxTZ+HYAdQ03xhqN74U+YecYnDKL\
zLK5YSkpctSvGeHq4amm7Qm5OdPEcknyxlJ4ZezlJyqctKM6q9KHAOUZ1KrDgrjjC8RZhUoqrhMqrYH\
NMHnWLnCEJ18NToQwmMyj61Sgq9WlRhndR4ynQ9lhXVzDEYfAVPtYi9UqQ9rKM/Mhjmtzt2nlZBLLg7\
tvGzkZ5FVHe8tGlnaO3Nu5BMX2kgRTMcb1ka2UKjvtDAgjfJvLKpc1q0jKrKVYBlYFWVgCrKRggg9QR\
XuRqJP3oKSej6afKyT87X73PzO3Z2K/ny/wDPlc/992f/AMl0UkTtFJ9nmkDM5drViTukhXBMbFmJeZ\
N2CTyy4bJbfgpSai17iaeqfvar7/8AhnddA+Z8M/H74QfG7wZ8XNL/AGpf2V4NP8Q+MrvT/D3g343/A\
AG1O/0Pwr4e+OngzS765j0nX4/Et4kEOl/FDRbTU5orTVNRmlaPTLKG2tnNtaXOg+I/xb+KH7Un7M//\
AAUA+NE1pNfa78Dv2lfhbbXnwsuvBM+rah8OPjt4M17wvqPigePfDul3t4kUPxCtoNS0fxz81vazzaf\
oeoLJqel+H9TvLu2T+k34s/EC1+GfgPXfFczW73ttb/ZNCs7gxsuoa/ehodLtjbte273dusxNxdJDIJ\
ls7K5ljBMeK/n18bfsYfAf9r7xb4N8MfFf4X6P4t1a71jR9Ks/E1tbaxp/i7StIhn1Myxt4h8I6np+q\
3fheyg1vXL+bTZL5dO8wPeSxLLEtxH5ObZPlee4Grluc4ClmWBquMnTqwU4qcJKdOpG+sKtKajUpVYO\
NSlUjGpTlGcYyWkKk6UlOnJwkuq89GvNNaNPRrR6HqHwu/Zk/bV8e/DzxJpraP8AsRfGzwLrtxNpFp4\
h/aR8E/FLQ/Gtw0Gn39vfa34Xh+G8P2XwpcRP4i1PToNT0e9ivVbQklWa3vYpGr65/wCCffhj4jfsx+\
NPjd+xf8b/AIv+Ivjn44TxL4m/ak+G3xW8R2lxpVx4y+Fnxf8AF12df0W18Kw61rUfhGLwv48eTTria\
+1ptS8UajrV74lksI5Ly8uJvzr/AGuNA+KX7BOsfsu/sYf8E6f2l/j1J+0j+0Fc2Xw1+Gvg/wCKfiPw\
j8bfhP8AAv4M6dJbaXqPxE8QfCqbwNd3fhyytry3S707W00i7tIdM8B+M7m7knh026069/Pf9pr4V/t\
72/7TGnaP8Dv+CjPx4+L3jrx744t/hF8bPGWj/Fuf4c/DP4G+NLb40/BvwXYfBm88W/CnXtBPxXbwZ8\
Qf22/AFhrF/oPwt8K2tkvjcJYeHoL6w8U+HfB/5PjszyLgfEY3EYOOccZ4/KalLDqFbGTxawLrwUpUK\
WIxlT21WTo1KMsTeWMrWVCriJpxnVX9heCf0ROLfGGfC1fP+NMj8JMg41wOYZjluKzb61Uq47B5dWq4\
apiY4XAYeusLh62Mw2KwuDrZlWy6nja+Gr0cA8VXlh6Ff+rH/hgf9hX/AKMs/ZM/8Ry+D3/zHV+T+of\
8Etv+CZmkftWfFH4V/tBfs66FHZ/HTUG+LHwL8WXPxT8e/DT4e6jZ+IJfC3gjxL+zn4d8H+D/ABL4Y0\
LT/E+meMrhrzR9E0O01Ka50HxhatqDxXkYbUPw68Hf8F5f+Cmfwl8Uy3Pjf4lfCX4322oeEtHubbw14\
x8C/DDUPC2nf8JVp3h7xZpWsxaz+z3L4du4fFttpNytneaZd6tJ/ZVzqGoaZrOk2+t2LR6f+7vhr/gq\
B8F/ix8IrLwf/wAFOP2Z5Pg2t7c2nhG98YiHTPiv8AF+M974ctdGl+GupeOvDGoXeofsnftRGTVfHdx\
L4K8WzaZ4i8C6Ppwu9e8SWU91EzY5Hx34T8Xzng6uRUsFKhJOUcxy3DxpQndxi51Yqvh6Um01D2tSDb\
TS97Q/ofxS+id+0D+jth8NxHl3itj+J6Wa0akaVbg7jXN62OxWGcKdSvHDYCtPK84zChCLpSxCwOCxU\
IRdOpUSpOMz8ff2rf8Agjh8E/gr8QtS8Bt4L8cfEn4UeHdR1W503xH8HtS024+LuneEPFmkeE20j4d/\
Eb4ffETwvqOkeKreyntLMWtz4PTTPNttV1PU9bYoul6H4f8AKvDf/BPj4R6J8JrTxL+w5+33dfCm9+H\
Xxk0Px5Z/Cv4p/G/wx8KZfEHjWFvD87+Pvhz4f1HxL4AsfDOt6PZ6fpINzc2B07Uo7y5+yX/2/Sr3St\
Y+8Y9J/a+8C3MvjX4FeNrb9uf4e/ELV7XxT4d8A/EXxjpmm/FaWz8ZSXepRH4bfHGz0+4sfiTbap4l8\
YJqkc+v7VsdA8L2mi6Kt/cXsd1D+q+k/Fr4fS+AfAvw4+P/APwTY/aX+JXjL4ZWOo6frEOo/s0+Dfjn\
4Q8OeMdcuYr/AMewfDnx1qlxDD4h8Hza/AUstVtLO0TVbDTLG5eMlV2lbwfpYGji6HDeIwuMyfFXksF\
mdPE1HT5qnOoYfMsDisLiY4dOc6jjjaWZVp1HGEcTRpWjH+Ql9Krx+jyYXP8AxDx3Ek8K6lOcM+oYHi\
D2jcY0pwxdHiDB5lHEuMKVOjGNfmVGlShShGMKcYr88/8Agl/+z1+13+0J8Eb39rL9n/8A4LF/Em+k+\
Kut+J/hf4ru/i5+ypYfEz4iabY/s9fFn4t+EvCnhLxXpH7Qnxh13WPhfrNsdf8AEOrXGgLJAtvN45eQ\
yahBJa38/wCliJ/wXXRced/wSbkbdndKv7X2QMAbQIVQYyM9M8n2x9Nfs1+EfE1/8Yf2jf2itX+HfjD\
4W6J8ftP+BDaB4V+I+qeHpPH80nw98C6rpt/r2seFPDH2iH4e6fNaa9otnDpF9ql/rKXvh/U7rUYtMW\
5tdOg+0K+7wHA2ByzB4fCYHN8ywns4/vHDH4lxq1G3KdRUq9SvSoOpUlUqSjhoUoSlUfMpcsOVZr9J/\
jnijGTzHjzhDgzj3MuSjShisfwbw9hcXGnQoU8NTjVxeSYHKMTjuXD0MPQpvMquNlQpUIQwzoKdf2v5\
ITftEf8ABXHwO3/CKeLP+Cb/AMI/j3r+jMstx8WfgX+2B4M+FXwv8UzXg/tG0PhvwN8adIm8TaNFZWF\
9Fpd+upMftd/pV5eWRWwuLQB4/wCCif7VPw4I/wCGkv8AglL+1f4XGsOyeEf+GX/Efw+/bNa6OmEf8J\
H/AMJuvgG60f8A4VyY11DQTpf2zzhrIub825iXTJjL+tlVZ1aNjdRo8jqgjkiQkmWEPuyqFgDMm5yvd\
gzJ1YFe2OQZxCyw/GuYPk0pwr0crrUktlGbjgKOJnaPwzliudzSnVnUvNT8/wD4i94b473M7+jFwh+/\
1xGKyrMuOstx86nxSq0I1eLsfkmE9rUX72hRyL6pCjOpRwWHwf7ipQ/InU/+CznwR8B3Wg3X7QH7Lv7\
fX7LXgPXtXl0CP4s/tB/sxaj4T+HVjrv9ha3r2n6LcXnh/wAU6tqV9q17BoN7Fa21hpl7MWVp5khsYL\
y8ttcf8Fzv+CWhAz+0+6kqCVPwR/aKJXjJUsnwkKlh04JGehNfrQrKyhlIZWAZWUgqykZBBHUEVla/o\
GheK9C1rwt4p0XSfEvhnxLpOpaB4i8O6/ptnrGha/oWsWc2navoutaRqMMlvquk3Wn3NxBc208ckM8M\
7xSoyMynN4DjWkpxw/EuArreP1nKqsp3slyueHzTDQULq6/cOa5neUkopbw4u+jFj5YSeb+B/FmU1Y2\
hV/sTj/AUMNKHtJSdVYbOOBc7xLxChLlaWZU6E1Tp8tKjJ1Jz+XV/b+/YRdd3/Daf7JyDJH739on4RQ\
sSACcLN4vUkcjkDFe9eC/iN8P/AIk+HdL8f/DLx74O+IngfXRejTvFHgTxJonjDwzrK6XqF5pGoXOka\
74dvbi21B7XVNPvrW6MUsnlyafNDJtlgKDwr/hgf9hX/oyz9kz/AMRy+D3/AMx1fMXiD/gib/wS/wDE\
2u634h1L9lfSIL/X9W1HWr+20H4mfGvwroMF5ql5Nf3MOi+FvC/xKs9M8N6Sk87rbafp1na2FnCqW9n\
bQW8ccS3GvxxQnzfUMqx9OSacPreLwjW1nz/UsapfaXL7ODu4yU1yuLzWA+itj6VSm+KfEHhWtCUZQr\
LIOHOII1I2kp0pYb/WXhp0ZczhKNdYqurRnTeHbmqkP1PVlZQykMrAMrKQVZSMggjqCK+OvE//AATt/\
wCCfvjbxL4h8Z+M/wBhb9jnxd4w8Xa5q3ifxX4r8T/syfBTX/EvifxLr9/carrviHxDruq+CJbrWtcv\
dUu7q5u7u5lluLm4uZJppHkdmPya/wDwRz/Z88H3H9l/s/fHr9tn9kTwNfN9su/hv+zb+054v8M+BdY\
8WSZgv/GGsWnjmz8Q3U3iy60m30OxeZL2KB7PwxZxLbLNFJNcXX/4JrfHn4fD+2f2dv8Agqb+3L4Y8b\
XJ/szVL/8AaT8ReEv2vfAs3habN1e2elfDXxto2j2mieLG1ay0R4NcjuXuLazt7+wSBo9Tlki93JeO/\
ErhKtWr5Hg8fktbERUa1TJs5VGVaEXdRhKcstlWjGV2lXdBKSbstG+ep4beA2bqKy36QkMCq7/criLh\
DN8H7F9Pr/8AYdXin2HW/wBQ/tS3u25ry5fon/h3H+yJpf8Ao/w38BeOf2dtDf8AfXfgn9kL9oH9ov8\
AYx+Guqas3yT+Kdc+F/7KHxY8G+Hde8cz2cdjaXOv3ulz61dWGiaZp1zfy2Ol6db2vw7/AMQ7v/BLnw\
1/p3wZ+CX/AApbxRL/AKJf+KfK8HftO/b9Ak/fXWgf8IF+3v4M+Lvg/SPN1GDS7n+2NN8N2PiW3/sr7\
FZ65baXqGs2Gpesj9lT/gq54cX+3NF/4Ks+F/iFquhg6vpXgDx/+w98HvC3gfxxqWm5vbLwf408W+DN\
fm1zw14T1O6histR1DSFk1Sys72a409GuooVpEj/AOC7CZzP/wAEnJc4/wBan7Xp24z93yUTrnnOegx\
jnP6FkX0p/H3hf61DL+M+Ocpw+Yez+sYWWaTxuDxsaXP7OONwdHNMdgMXTpupPlo42nUinKUow1bOSr\
9Hng/MbTyXx38OuIadHSVT6xxDk8qUnayhHiPhfI8TU5kk/aYWnVpxtyzqRn7p47H/AMESNM8LzH/hV\
n/BRL/go58LdP0of2h4K+Efw++Nfg34E/snWOrWwF9/ZGqfs3fsbfDX4T2ejeDNS14XF74lsvBOqeCN\
Z159Z1fUYfEml+ItQn19aev/APBMT/goU+ha14W+HP8AwVT0n4ZeGfGek6loHxJ8O6/+zD8bv2w9C+I\
+hX9nNpyaLrWkf8FHP+Cg/wAabfwxpKafqOvQXNt4Xj8Pw63DrzxeJE1pLDRl0z334Xft+/E7w58fvC\
X7Jf7fHwN0H9mj4o/EPSorb4GfFjw148/4TH4BftJ+MdB1Sbw94ktPAPiGbTobj4Ya3f6gdIv/AA74b\
12a81prXxNYaXq72Os6joFt4i/U6Ke8cujW9uskRCvm5dQ4KgiaNRbNiFju25OcoynlTX3OW/S08WOI\
8PiHLifL+IsJQk6OLy/OuF+G8ww3tFGLVPHZRneS18PVlG8K1L6zhJxjNUcXh5cyo1Y/nXHHhDxF4V5\
rlNHiDALASzbD08xyrMsszSnjcDj8I6koQxuVZxlWMr4TE04V6NShVlhsS6uFxVGvg8VChiqFehD+bn\
4c+Gf+C3vwO+I+m/sq6b+1B8Pv2gfi/wCCfhTf/EH4YfE39qjxvpunfs7fHz4UaD8QLn4ZXmp+OfAPw\
h/4Jd2Xje2+Lvh7w7q3w7uvEGixftE3uoW2tfEHw1r914i8ZaTda3pEn0j/AMLI/wCC8Xg//iWfEj4V\
fsq+Odcn/wBOtNW/ZC+AGn/FX4a2+ky/6PBp2ueIf2r/APgrV8BvEVn45S8tb6W5srLwhqWix2F3pk9\
t4kvL641HS9H/AFL/AGhPhHqPxt+HFz4Z8O+L9f8AhJ8RtE1bSvGfwm+MXhzSPC2veJPhZ8R/Dsskmj\
+JtM0vxD5lvquk3Wn3Or6H4i0tmt08QeE/F+v+Gri6gstZunpfgT8dbH4z6F4w+2eF9f8ABHj74VfEP\
X/hB8XPBGq6X4iaHwz8RvDFjo2rXn/CMa/q3hzTT44+Hmq+GvEfhfxB4Y8QRWNmuteHPF2l389hpd7N\
d6VY8GT+O1fJlh8hxXhDwJj40oJYTEV+Hqcq1anC96FWUMZH2lfDwUb1JQhKvRlGo3WrU8VUV53wxh+\
IMhXHGTY/HTxeHqezz/De2lN4XE1ZQeHzWNsNSp08vzapUnRjThOv9SzChWo13hqOOyinX/K+X/gob/\
wVG8PIb34y/wDBHT/hSfhqTNtpfi3/AIa68Y/tPm78RuDLZ6GPAP7BH7FXxc8YaT5unQ6rcHVtS8N2P\
hmEaWbC91y31LUdH0/Uyv2++22wYK8hhJBK/aI5bdWClQ21p0UMRuXgHPNFfSx8TvB7Er22Y/RlyvBY\
mWns8p4i4qw2D5Vs40s3zHP8Yqj/AOXknmEqcnZwpUlo/wA9+pZgrKGczlHvUo0HLp1pwpRt29y+u7P\
5rf2nfh7/AMFG/D3ia28B67+3Xd/tEx6PZx6jdW7+Afgd+yjaeFtd1C3RraK4s9M/Zn+Kkfj+eTRL2C\
4guvM0kaWWktgmojULoWGj+yvof/BW/SNQ1j4rXPhb9iTxRoGgiTw79g+GnhD4oePviXcX2pRQG5m8C\
eFvil8a/hzoE+o2y3Ol/b5tV8b6AsejanqLWH9r36RaRdeJfCnxt8U/2uPCWg/FDwF+0fp0ni7xLfx6\
R8RtA8I+Dvhv8SdO0n4uw6boNp448K6ff6HbQpqN8fHD67dwXVm0um6tYeI9MvNBjOjzWN3f/Sv/AAU\
AvP8AgqV8G/2HNe+C3gD4f/sieOtS+Pbaf+yX4dg8J6R8cvEC6R4g/aN/tXwPHr/jbW/Eni/QtP8ABO\
iajrmvPpNrrd5df2fp3iLxroaSadc2khsW/i6qsJh8txOMpVs8w2WU6Sq0an1+WJhUi7SXLWdbMMYk5\
Nc3t4uaUnGnBwpqEP3vIPHPxDzzxmyHwz4w+i1lmXcV5znVDJq2Lq8HcGUMBGpOtDCV8TXwfDWeYDKM\
BQwNHlqTnWw+U0cQqbxPPXrTxeJl+AGvftn/AB5/bB/ag+P3xL8B+FPH/i79o/4t6R8Jvgp+zb8S/h7\
4k1L4M2X7NHhC4+M3wz8GWXiPRPDmsa/4quPhBq3jLULzRvDd5Na/EnStE0u+/aB8V2d1qOuQ+Jgo9w\
079tgeLZvCnwm/Z6/Z3/aF+CfxXv8A4tfsrax8Kf2fPhp4IX4xeFvAP7J3wC+DvxK+LPw28WeGfC+hX\
fg3xJ+0j8XV+Ovxt8W/HGKPxnDe+GvE93pfh3UNe1G+0q3vBqH5eaB4f/bK+H37P37S/wAYfgp/wkPx\
D8Dfs9eO7XW/DWs/A79q7Sfhr4I0Hwr48/aP+Fnhz4Q/FnWtB8S2Vr4q/wCE78ReIvgtpjxeGb3wr4O\
1qK4+B3h/4i6rf6NYWngTQPFHLePv26P24Pgb4j0L4M/HLwV4n8Fa5+wTqX7Q/wAEPgzpfwEOgrD4R8\
Sa1p998PfHWreEvGn7MMHhXxTqXi6/1/RLrUxqviQPpup3+ned4pvr+LXtX0vU/wCZqa4jwtClmGNzB\
1nm1SNV1KOIyutLERxOKrRqSoxjiYZgvaU5Y2XtksQq8sNRoV6MXg4vBf8ARTguJfAvjbM8w4K4U4Fx\
nD78NKWKyupgc+4Z8Rsko5LiuHMhyatQo47E4vh6rwTjIYPGf6q0adDD4vL8LQo5vm2bZDnePp55i48\
RfsT8Wfj3+zNoP7RGs/E3XfA+rfBv4n/s5/EP4m/FwfCj9rb4E+J/hF+0l+1HefHf4XfALUNUsfEfxN\
/Zs8Jy3vwn+OEPxGT9p3x/4N8X6pLYWHgfXviX8Pf+ELs9P8LxT2vgj5V/aV/am+EfjfxbP8Cv2NvjP\
4u/Zq0zw14lHhvwn8ZhoFt8OND+P/hzxx8dYpXfUfEXhaztvEf7JPwtsrzxhrXi3VPBmmXcHwk8Qar4\
cTxdpfwy+E3iOZfD8ur+zF/wVb+Jnwl/a/1b48/tGfs//tMfGLQPh/8AtA+FdGuPjz8UvhH4T+Ed7pn\
wu/ab8D/GuW28beGvDEsd9oWk+LPG/hCz+DWv6Pr9trVtfWfw++A+h+BtK8T23whF7d6DxX7Xf7bv7E\
PxO/besdcg8I/CDx/4I+NuneINV1H4R694q8VeBdG8OfHX472mmx/Ff4t6p8R/hf4A1/w7r9rpXwT8D\
/CS6vNY068ubbW73xPp3j/wPc67rd1e65L9ThMFXxVHMsbDNKGBxDxknWoVMHVp4mnh50lJYqeKwmLx\
EIqlQoRnUp4OMowhgqM6sY06+MhV/EeKePOEOFc44P4NzLhzG8SYTA8K08TgcxocVZVicnxOLwmYyw1\
TLqfD/EOTZPjKtPGZxmOIwWGzPiWrQlXxXEuZYbAYmrjMq4cxGB/Tn9hz9pb4c/sd6t4E8c+OtZ8K2n\
7K2g3uieG7j4e+MNa0Lwh+0N4KXV7u78I+Af2kfA/wcOra9p37THwzuBpNvrHjPxd8LPEF1pviTU/GN\
v438L+ENM1TRPHQ8Vf2OXEUm5bi3VDcRgqVbjz4Cdzwb/4DuCsrHIDLj7rNn/O0l8e/sn/sbfEnSvhL\
+0V+1F8Mvjn8OfDfwxi+N/7OX7XPwf8AjHpl38Wtd8Z+Cf2evF0XwO+AXwv+MPgv4+eL9P8A2aPh94b\
+NvjG7urObTNC1pp/EfhbwprniLRp/BWoWFzpX9vf/BOvwr4z8FfsPfsw+EfGXxJ8O/EvxJ4X+Evhvw\
7qWveHV8GahoWjnRVn06z+Henaz8OddvdI8SL4R063s/CcurWt7dHWJvBMmqzyC5vJ1X9i8NuIM1xmY\
ZplGKwqoZdgFOFJbrD1MNUhQq0XOK5alLEOblQdKU4ReHxLjU9lUw8V/nP9Nbwv8M+FMh8O+Ncj4wpZ\
hx/xxGGPxdOcvZVs9y3NcN/aWHzOjgakvreGxORxnhcNnjxtHDV5Rz/h6lWw0cwo5lUq/a8csc0ayxM\
HjcZVh0I6d+hByCDyCMHmn1luLmyYzBrRoJpQbgFJLVUkcBFm375Mbn8sOcEDAOBl3FpnvApItrdiAS\
FW7fcxAyFG60AyfcgepFfr8qezg04S2baXqne2qv2WmuzP89r991/XmWqK/ED/AIKq/BD4gW/iXw7+1\
54a1SytfCvw/wDBPh3wd45sv7Qs/CfjbQP+EY+IF54/8E618OviFD4Z8RXfg3xVrPja/wBG8O2usaZp\
JvNDu9Ws570Xfhq98Qtp35ZfsA/Eb/gqJ+154F+JHibwB8Yvgb4yh+EvxJ1Dwp8SPCHxE+N/7but/tG\
6cthp1lNLD4J8H/C79rrwX4P1Cwvp7HxJY+HT4j17w/a6l4h8PazZX/ibTtOs3u9P+fzXPsJlGNy3L6\
+HxOIxOaqr7JYehOum6MYznGUqaaU3BuUY6ycYTlZKLZ+r8BeD3EviHw1xlxblGb5LleT8CSy9ZhLNM\
3weX1YxzKtPD4etTo4icZzw8cRGnQq12o0oVsRhqPPKrWjA/sBA+zShQGMFzK7Fi2VgnfB2nc3EUj5w\
AOJGxz5ihbdfzQaT8Rf+DgTStUsVv/2XdS1DwPA91av4K079pn9jjwvq9vov9n3lvpNhpfxO+J3hLx3\
q2py2dydLEt3rcet6pqEEErX+pyahO1+ZNV/4KZf8FKfh/qtz4S8N/sUfH34wW1oLeeTxxqn7O/x2+I\
un6pc3VrFO1v4U1+2/Z4+At9/Ylta/Z4Z4NW+H1vfJqsOpyQ6pqWky6Y8XPLi/JFSVbESxWATdl9ay7\
McLKdt3COJwtKU1HRTcItRvByac1f3o/Rv8V8RjJYHKMDknFVanDnqSyPi/hDPqNCLaUFicRkue4/D4\
adW8nQp4irTqV1TrujGaw9d0/wB6/wBpL9oT4cfsqfA/4h/tA/Fm51a28BfDfSbbUtXTQNKl1rXdSvN\
V1bTvDvh3QNF05JI0l1bUvE2saPp9s91Pa2EM2ppPqN7Y2MdxeQfzc/tUf8Fmv+Cj/wCzLZ+Ctc+IPw\
K/Zi+EOofFLSbfxp4Q+BnxQ0fxnrnxp0jwT4g13xw2i6hq0HgT4/yPFpOm+GdH8F2uq6j4u0T4c6vfe\
J/Eep6Tong25t/DWvXth+Y3/BUf/gqn41/bG/s74IeK/h38Q/D/AIA+Dd1458Q+I/h/4j+G3hH9nP4p\
6n+0bZeHfGvw/wDBel6xpN58Wvit/Zuk+EvEGpRy6zaXOreHJ9R07XvEWnPbRazp+g3Y5nxP/wAFINC\
+P6eNfij8btW8e2/x78d6Fa+FvFXh5fH/AMR9F0rX/DPxc+IZ+EOueAPgR4K0v4QeKvhb8H9C+Hn7IX\
iD9pTRdJ1Px1r2o6jfXv7Y2v8AjO41VfEVkton4lxjx/iM7zLM8v4X4ohllLLKdNYepRxOFX1mok6mN\
nKnKca1SdKLpUMHQvRhVrLFTnOpbD0qn+mn0bvojZP4YcE8DcYeO3gRiuOMdxvjMVPN8JmOR57UWSYK\
c6WE4Zw1PF0MNUyzCYfH144/NOJc15MzxWBy6pkeGoYXBqWc43C/oz8Mv+Djz9oXw3431/4eftS/sz/\
CfTtWh8WaZ4Ou7jStY+LPwPb4R6np+s6ho3je4+J2g6r4Z+I+t6k+nXf2R5rTTdJt9V046DfQrp+q3k\
8Ftb/t7+xV/wAFc/2PP24fEx+G/wAOvEnivwT8W5P7cuNH+GPxa8PWPhbxR4t0Xw9p+nalfa54VvtA1\
3V9E1phaXl9IdLh1c66sHhjVtRfSU0mya/b+Qf9pH9oj4V/tN/Gb4k6z4o0z4dWnxC+OPjL4YazpWhR\
fEv4O/CH4L/CX4K6JrP7UHxL+NHwZ+GH7Rnx78SyeGfBHxe8YeJfCHwW8R3/AIyl8P6Bean43+LHiyM\
6RFoniTXbfxPRb9pj4N6T4A8V+HL6z8F/tc+JvCsnxL8TN4n8beIPCviDX/inpX7RGn6p8ZLX4pajd6\
C3jHR9O8ZX/hfwbNp/xP8ADsdzoH7Tuiap4G0uDwl8cH8LWD6B4C8vIuNfEXJsXXhi80jxPkOEqTs6u\
HjPETSqv93z4NzxFOrOg414uVLEukp0oVqVNypU5foPin9Gf6GniXw3lVTh/gWv4GeKfEGEwsmsDm9f\
DZRh6tXAQ/2yOH4ijh8oxeBw+ZwrZXXhRx+SLMKmExuKy3HY2NDG4yl/oi0V/Ol+yR/wUA+MfwU+G41\
j4k+Ffi1+07+zbofxs+KHhD42/G/Ql8ceL/iR+w1qVvL4g+Iuo/Dn45/Dfxnc638RYj4N8K6v4etvGm\
la1qPi+P4fLoty1h8XviVNrek+CfB/9C+ga/oXivQtF8U+Fta0nxL4Z8S6Tpuv+HfEWgalZ6xoWv6Fr\
FnDqOka1our6dNJb6rpN1p9zbz21zBJJDPDOksTsjKx/oXIuIcHntF8lOeDx9GFOVbDVYyjUp+0jzRl\
FtKNalLVQr0nKnJqUG41ITpw/wAcfFbwd4i8Ksxg8Vi8LxHwpmOIxVHLc6y6vSr4PGvCVXTq0qsKdSp\
Wy3MKXuyxGV5hGhjaUKlLERp1cFiMLi8R88ftffsx6F+1t8D9d+E2o+J9W+HfiaLVvDvjj4WfFzwvZ2\
c/jb4O/FjwPq1vr3gf4jeDLycx3Glata6hbPa3UmnXmmalcaRrGp6dZ6tpr3pvIvnH9gT9rnX/AIv2f\
jb9mr9ojXdKtf27v2W9V17wh8cfDVv4fvfBNj8SNA0rXH07wl8d/hvpGqQWreIvh34j8M3XhG9m1C3s\
NLhg1HX4LtND0fRNZ8NJf/pXX5jf8FDP2ffjJd/8Ir+2r+yJ4h/4Rn9q/wDZf8JeMJrbwtH4Un8SaP8\
AtPfBuf7J4n8Wfs6+PNJ8Nae2t+LfPudDluvCVjBM8dtrurXIsI9L1jU7PxRoHDnmHxWV4yPFWV0p4i\
thaap47DQu3i8FGTk3Tg6tOn9awvNUqUZNOVWnKtht6tOVP6zwnzrI+N8greAvHePw+UZdneMnjeFs7\
xXJTp8PcSV6MaHssbiKeCxWM/1f4g9lhMDmlGE6dHA4qll+dtqGBxlLF/ptHIssayKCAwztbAZGHDI4\
BO11YEMOxUjtXxz+05oHjb4ea74Y/a1+E2i/EPxr4m+E+k3mgfFz4F/C7TfCN1rv7SnwP1S8DXmi+Rr\
0MVxrfxD8AahqOseM/A1ta3sd3eTP4o8GackL/EG8vbfuP2YP2o/g3+138H/Dvx4+BviJtf8AB3iNvs\
GtaZeiCz8UeA/FNjbWr6z4P8c6JHeTDQPFenrd2f2qFZJra5tLu01XTbq+0i8sb+8+ka9utHB57llKv\
gcYp4bFxhWw2JoyUuWStOlWpyV4z5Zcr5ZKVOrC9OrCdOc4P8zwc+IvCrjfHZdxLw3LD5rkVbE5bnOS\
5nRqUfa0pKeFzHLMbSkoV8PKrSlUpKvQlRxuBrezxuAxGGxuHw2Jpcl4B8c+Fvih4F8FfEvwNqn9ueC\
fiJ4S8OeOfB2tfYdR0z+2PC3i3R7PX/D2qf2brFpb3en/AGjSdQtJfIuoILmLzvLnhilVkUr4g/5Mm+\
Ov/NWvE37M37X/AMWv+x18H/srftS/E/xj/wBvHiDRvhL8X/H/AI1/6a+HfBvjvT/+XKy+IH/ElKWWY\
6piqdWhi4KhmWCahiKcb8qk1eFWm3fmoV42qUpXbScqVTlr0q1OEcb8LYXIMVgczyHE1Mz4K4npyxOU\
Yyoo+1lSjLkxGBxsYKKo5plle+Ex9FwpxqSjSzDBqtlWPy7GYr8MPhf4M1P9hD9t8/tYaT4I0z/hiT4\
l61rvif8AbK8aXN1H4j1z4b/E7VNB8bar4F8ZXNp4n8SWg0LwfD4sg1G/0dNJj1TU9S13xrrfhix07V\
PEWp/Cjw5H/TX8WPBuhftK/s/eL/CvhDxvpNtp/wAV/h5JefDL4ueG1s/F9n4W13VdMi174UfGvwJea\
Zq1umpatoXiZfDHifw9qOn6jazRX+hWGoabqNpcR295F5b4Y/Zy+H3jT9mi8+C/xl8B2Hi3wx8TdKvJ\
viX4N1uw1x7bVk1i4t7zTklaWO3ufDvirTLSw8PvaXdjJaXWk6voiX1hcw3sSX1fCH7Fnxs8e/ss/tT\
+NP8AgnD+018T9D8Vjxhq3jH4j/sFzaboUEmuJ+z9ZN4j8RweEvG+o+CvB+ieHPBmlW2jaXr1l4Y0Kz\
0jT7bQpvhD4u0W3i0rwiPhZZ6x81WpLh7Mf7NxcOfhbiupKlS2hHCY3EJqeFdvZ8lDHN82H9nzzeMq1\
Yvl54M/eMvrYvxe4Ko8d8O1nR8d/AXCUcdjm1UxFfP+G8onSqYXOoRqwxn1vNeGaa9nm31r6vhY8OYL\
A1oKvLCYmC+avjl4E+Fn7IP/AAS0/wCGI/HPwO8Jf8Lf/wCEt/ZeudW+BvgTxv4i/wCM/fEX/DRPwNv\
viTrPwO+II0Cz8TeO/Fuu2Wj3em63plrpP/CU+AP9As4NJ/4RD/hA9a8QeefG/wDZF8SfBPTPCvwm8W\
eGvh58Zf2ifiB8Q/g7+2n4W+K3xt8F/Cf4i/A/x1+158eP2gfg1+x/+3l8JfHWiN4DtdT0n9mK+g+PH\
7PGv6Jp2l+EtM1aO7hk1iDxAdV8OaTp2n/0W/GL4H/Cn9oTwppvhH4q+GV8T6Noni3wz4+8MX2n674h\
8KeJ/B/jvwZqS6n4Y8a+BfHfgrV9P1rwP4tsrpZki1LR9RsrwW97dWbTNaXd1BN+LH7eP7A37dmufDj\
4aH4FfFHSf2p/E37N3xD8EfFb9mzxX8ZbT4a+FP2vPhb4u8Hy/CrRLLR7v4u6p4XTwj+0L8PL1NG8Y+\
IdcsfEVh4N1u51bRfDt/qniTxo+kjRdS+J4r4PxGX4bF4rC5VUzbD4DL8Pg8FTwdOkq9Gnh6leU/a0I\
xjKvW5a6eDlh1L2eIpRk6dCM69Wp/Sv0fvpHZRxZnXD3D/EHHmD8Ps54t4wzjiPibF8SYrGyy3MMZm+\
Fyijh3gc1q1qtHK8vdbKZw4ko5vUorGZRjqtGGNzavhcrwGF/Cz9raHS9C8W/E/473mh+LPCHwq+Hnx\
kh8I+O9A0HxXffFHxT8Pf2kfh74Q+DHxa+Pvw/wDiV4ok0i11bwL8SPFfxkg8AfCXSP2kPAt1aanrS/\
ACW78cHxfqnja+8davwXi74NfGTWPD/wAYPgh4Ji1bw54X8Mfsx+NP2vf2nf2Vbzwr8H/hX4h0K4+GU\
vwr0Dw18RNE+Mng34dT+C/itpNp4hj0PWJdP8B2Hg201Twv8Br3Qr+Gx+I+q6rNf+p/tXeOfhh8EvhJ\
41t/gL8J/EXwU07xT8I/Gv7K3xP+Hfxw+EGtfCPXvixoXgfwD458J/Dz4mW/x28M6JP8NPEnx7trCx8\
Z+JrkaZqd2vxIt/Guo21nMdbg8N6dB7PoV18FrL9mnx14l8PeAfhn+0r8cf24tE+Lvw6+DPwg+BXxFv\
8Axx+23+xH4KX4ZfG66+AnhLw34C8D/FzxjNbfBfUfDNta3vxE8NeHZ/Atp4Wg+IuveEtY0Txh4fntv\
CeifC4/AYfAYTNMveLjRzDMKPtcRKnUcOT6x7RTp0XSpe0q87nhsFLCVcPei62IdbC1cNJYmh/V/CXF\
md8XZ/wHxdR4erZlwfwhmMcDlFHG4OniPb/2QsE8PjMyhj8w+qZeqEcJnPEtHP8AAZslmMcsyenl2e4\
LOqNXJc0+ftO/Yo8Nf8FWv2+G0Lx/4eXwx4t/aJ+Hnxa/bB+PkGnaT8K9S8Ofs++Cfir4S8L3n7KugN\
4dHhTS7b4yas/h/S/2TNa8W65Z3S6v4qs/iHpem6tZeGfE3g/Xtfk/df8AYH+F3wX/AGr/AAz4k+HH7\
bH7KvhD4Tftm/s+67rHwp+IHhrwvbeKfg3pfxN0Xwbp/g7XD8WtD8O/DO40bwvruoSRfFDwsNdn8OTa\
taRR+JvDetpJpfhzxh4N08fTv/BI79gvxT+xZ8G/Hfib4wweEoP2jP2jvFtr8RPivpvgbT9O0Twt4F0\
61gvpvCHwp0vRfCU8XhmD+xb3xH4xup5PDel6dpUFz4um0XTm1HRtF0jUJ9b/AIKDfs267Za7o/8AwU\
M/Z1+HmrfEL9sz9mf4eatoHgLwlYXN5fxePPBN5eapJqOiweGZtRFvfatYaf4r8ctLbWdndav4h8OeK\
/EvhnQksPG+o+BPGfgb7LhvhbOMiyShxXmNKrjsyxVSriszwGIvWlPB1FSSao8k08yw1Kj9aUKUKTq4\
ivisIlGMqMaf8SfSZzz6L/0l+OMR9GDHeHvBuY+FvBuEweS+H/EDyTKpZdlvFFCpi6uIcMRjFCGG4Nz\
3MsfHJK2KxVbGxwmVZRkHEM51sTQx9bF+zJ/wTx+AfhzSb7Tfg3rPxr/Z3udXvtOu/EGtfBT43fEPQt\
T8R2ulW2rQWWka7B4m1nV7G/06OTWLqWNjZrdQyAiC5ihmuoriDSf2LfE/hG8l1Xwf+2h+2Pb+JbPTt\
Ti8K3Xjz4m+H/ih4OttSvdIvNPt5vEXw+8UeCvsPiezt5LkTfZZHglYRLJa3Vpdwpdw+1/suftBad+0\
x8G/DfxPh8Pf8IT4gud+l+N/h/J4r8LeNp/BXim2gtb1rS38V+DdQudP8U+EtV8P6joHiPwprts0Vt4\
n8G+NvDvimygi0/W7QV9BSxJMoVxyrLIjADdHIhykibgQGB9QQeQQQSD+wYLDZPjcLh8Xg6MVhcTCM6\
cqanRspWkpKEXTcJr7SlGM4u6koyWn+U2ffRu8PeD8+x/DuK4Aw3CGb8MYiphp4fKK9TLKOExFCrNyq\
YR5JiqGEjL2rlWpY3BSarOUcVRr1FKFR/n3q37Mv7aGv6Vqeha7+33p+taJrWn3uk6zo2rfsffBfUdK\
1bStRtpLPUNM1PT7zVnhv9PntJpopoZUeOWOVkdWViD/AC+ft7/BX/god/wSp/a58O/tl/s+eOf2R4v\
Blhc2htvDVnovxO+FNz8YfgJ4d0vRpPiX8MvHPhu3vvEWl2tr4d0rRdAsr7V9Z1TU9a1tvEWheM7O+v\
fFmnaguh/3CQSO6lZgqTpxKiEleSQkiFhkxMFJHXHKk7lYDyb46/Bnwr8ePhxrXgLxPp3h+6nk26x4Q\
1fxH4Y07xhZ+DvHelxTv4V8Yp4c1V1t9b+w6hKDc6fcOLPVrCa80fUln0zUL22meKyXBYjCYnCVaTrT\
nyTo1a1SrXnhsRSlz0cThpVKrdKrTltKEoqcJShPmhJo+18JcBT8HM/xOdcKZ9xHUwudUJ5fnGCxvFv\
EuaYfNsmxMZUsflGIhnGZ5lClhcdRm41ZUKdOrCtTw2KpzjiMJh6lP4W/Z+/bP/am+On7OXwb+PPw7/\
Zp+HHx20j4qaT4g1KbU/h98arj4Tnw5eaH4ivdAv8AQPEHgz4xeCll0/VrLV7LVNKnfTNb8QWF1eeFr\
2+tL3+zbvTXuGftCft9/F/9l39nH4zftDftEfsP/EDw3oXww0XRr3wzp3gb4w/CT4lxeK/F/iTWrfwf\
4R8M+IJbDU7O98IaZqHjrX/B2myapFpesWmnW2vXeraoLHT9Mnnf8dfgD8Y9e/4I1/tSaz8Nvj98VvB\
Kfsl+MNItfCOr/D3wZo9nY698PPjhfan4P8UzeM18G+FfDmqan4/upPDPjHxLrkGv3V3pB1r4ZWdro7\
7vF3w30D4WWP8AT74+8J+BP2k/gV418Df8JL/avwz+Pvwl8R+E/wDhMfAOs6Pff2l4E+Kfg+80f/hJf\
BXiH7Nf6feed4f137Vpt55N5ZyeZDP5dxAdr/NZPj83xeEx2AqZlLD8W5NS5KtBrDujOt7OUaGLpqVL\
20sFiqkXUpudRTVp0aklOnI/SOMfo84HgbxA4C8Qss8X+M+IvowcbY+hXy6lUp8MVatPK6NSgsz4czT\
MXwnLHPifJsPUjTzKpDH1frGInQzLDyngcbRpv/OG0j9q39oX4OfE34r6z4i+DPxp079q/wATeNvDv7\
T3xkh8f/sn/Evw9498GeIbHwXrn7R/hSG18JeC7i11fVLXS/EviLVvij438P3/AIGPwt0bU/2ZPh9qO\
s6vrdlJD4cm8G+E37en7J+l/DW2+EWvfCX4T6B40t/iP8CviXqX7T3ibwL8S/EPxS8KfD+0vfFfjBdV\
ufhR8bfGVh4H8beHdX8NeMvC1paWV3BoXgrX9PTS7DxJa6xrmt+F/EOjf1z/AAj+DFt8AP2SP+CqPgT\
9obx5pXiz/gob4t+CH7bHx6+LOlyaNrehWMfwz+LXhXxHo58cfBSXUbS00Hxb8PfFOvfD3w94g8Qax4\
O07TXt76+8O+DfG9hYav4S0bTrH8R/iFpfw4+Ovxl/al+HXw9+LfxD+Cng/S/2Yn1v4Z6F40+D8uua7\
+0j8Ff2FP2W/hjr37OMOofEF7fwxrXhnSfiV8LPhxrvxI1HT7/QNJ8MWc3hDwbqH2bxXrCeHv7C/mXP\
cjwOUYTKsQ4YieY5kqsKGDljsI54aeJqYj29Ou8Xh68ljp1KMaeIlRxNDEYarX/dRdWlUhP/AKKPB7x\
J4+454l47yqXEGTYngTg6pl+JzPiKHB2fUo5tRyTAcOwyzFZY+Gc3yfDVeF6WHx2PzPKoZjw7mmT55g\
sKo4qthcrr4WrQ818Hf8FQf2SvGP7VHgnxtpHif4XfsieHrDx14L8NeNfHH7F99rX7OsHjz9lrwz8WN\
G8QeONF8b/DX4K/Ha61L4fXt98M9R+IHiPxjq9hrPj7UJ7n4WeBdB8OW2hwaZrfiPWfv79uf9nf/gjp\
4W8c/ASy+AHj/wCDWrfs+fFuwnf9or4j/CP9oH/honxd8GPAnhjx18NLbR/Fvwh8Mf8AC9povEmveML\
X4pXum65BfaZ4+ltfCvg658U+FPBsk/h7xA2qflZ8SovH3i7XPirdfEr4Ppaabd+KvFutS61rvif4Ze\
Afit8GL7wN4G+Ongr4Wfs6/FLxrpHhTRtF8PJosHwh1IeHvhTrfhPQNUk0/wCF1xpHwc8P+BbTxrenW\
P04+Ev7J37Gmo6jZ/tI/Cb4EfAz9rTwx47+DHhb4AfCzwN4X1740z+Of2UvGt3onjjXfD+mePv2ULL4\
9638RtM+HEHifwJZG/8ABPhi5+MusXfhf4Z/EX4oeCfFnhTwzaQeB/EUZTjMHnlDN8t/s2hXq1qlKtR\
xOPwsamJpOLnKs4UadKnOOGrezo0cRVw7lVp05wrVp0qzp1Kb8VMo8TPCjMeAeNsmz+vHDZbgsxy3G5\
Jw5xZi8ryPMo1sPgKOU08dmeKpZ3hqmd4Ctjc3x+VYDN6KwWKr4KeDy3DZlgJYzLq3x1+0D+zP8Yv2T\
PFmp/s0/GfUvib+x9+zf8UvFXiHxl4P17xVe/De90/4ofA/wDqVk2jaR+0LrfwP1y70L4zfE7wp4Q8D\
+DB4S8NX+sQad4X8S+JrZU1Xwb4X8TT6xJ/X/wD8Eefi/wCO/jN+wp8OfEXiDQfBcHhPw74j8e/Dr4K\
eLPAeseIH8C/EP4GeAPFF94a+G/iDwVoPjPQ7bxR4T8I6ZptjN4T0208Zo/jC9s/hxDrviKabUdYlkb\
+HvxT/AME+dG+O3iH9mTwP+y/8FPFXgDQv2s9C+B/wz+HXxs0P4nftaaVc+IfjB8Jvgb8P9A/au8XQe\
FNW+Jeq6fp/w18K+P8Ax+dP1TUdK8Et4R0fQ/2etPsfCEMOnaF4ph1T9m/+CQPxA+Jf7LvxmuP2Ef2k\
/j7+1v8ACbx34el8OfBjwp8P7nWfhnrvhD4d+JHurCy0G2034e+I/hfrujz+GvFUMnhOe08T6BGLQX+\
ptqi+Zo/iy51p/wBO8M8blL4mxNXDYnEx9nRnhMM8VCSljoN4fFUcIsRaOFqyw9KpiMZhZU44ariMHO\
LjKrCi+f8Ahf6euV+LuC+jzw/PF+H+Q8T5hLH4HiLiHLOGszw8KvDWIU8fw7m2fYTKsX7HM8PRx+Lwu\
X5FxBQzjMsRgcqz7Lq9J0sJmOa0KeF/sp8+YcGznJHBKSWpQkdShe4Ulc9CVU46gHij7SF4khuY26hf\
IebI9d9qJFHOeCQ3GSMEE/F//CjP2ybTxT/a2nft2fbfDVtr/wDaNj4T8V/sw/CzU/tehQ6j9ptvDvi\
XXfC+r6Hcah5mnqlteXenLpE02+Sa0XT3aMQ6HjSy/wCCg9jqlvD8O/Ev7GvinRG0+KS61Dxp4I+Nvg\
LVIdUNxdLPZ2+j6H8QfEkNzp62iWLpctfRSPJcSxG0jWFJp/3369NRcqmV16ai7aeyk35pQrVHb1SP8\
MX4iZ3h8LisXmXhFxRltLD1FTircPY6rWT2q0qOU8QZhW9npq6tOlKN05QS2+F/2grzWP8Agmf+03cf\
tk6R4r1uP9hn9pv4iaVo/wC2T8I9N+HGp63ZfBj4s6/4Xk0Lwv8AtUeB7Xwrp1tHoel6x4l0Pw9a+PL\
q48/U9Uvtd8xbXxbrWq+HLPwz+xHhrxT4Y8R6LouveF/EWieJfCniLRtP8Q+GPE2hazp+taFreg6vbQ\
3+lajpGsWF1LBqmlXGn3VrPZ3MMjw3FtOjxO6gO3yx4+8R/tZR/Dk6D4p/ZP8AgZ8fR4l0n/hD/H3hD\
wr8e3sNC8R6drOhXll4qn1Dwt8YPgzaaefBV5i4tZdLn1bVbjydZjtpRfQLdXK/kf8Ask/tK/tH/wDB\
OnxHYfsU/tu/CT4sar8LPiFLqzf8E7/FGnePfgN8UfG9z4T8FwWr+KP2cfHniOD4oaFc6n470ltd8D2\
vgiytvDrQ68NTGi6FdrdXOgeBNG+UwuKo8NZtXoyhVp8L5vJ1nKpGcIZfjas4pwVSvKMJUcdVqP2NCj\
Fyp4yc4JOGJj7L+oMV4rcKeO/BtCjUyriCh48eFuU0vbU1wdxTy8U8J5bhak3iFicFwzLAVc/4Qy+gv\
7TrYnM51sdwzhY4t+/kGLq4z+hPx94G8LfFDwL41+GnjnS/7c8E/ETwl4j8DeMdF+3ajpn9seFvFuj3\
mgeIdL/tLR7u3u9P+0aTqF3F59rPBcxed5kE0Uqq6lfKvgf9sXw34q1S403xB+zP+198N4bbT5bwa34\
y/Zi8c32lXc6XVvbw6bbQfDy31++jvZoZpp0aW0S1VLCZHu1m8mOYr18wyvhDPZUq2b5dgc1qUU4wli\
8Nh6soRbTah7dOUYt62Vk9GfnPht9LbOeBssxtPwu+kPmfhzlma1lUxNDLOJcw4dWIrU48katfC08Vg\
J1ZRg+WnVqUpXhpCXLc4r9lT4zfEf4deMof2Hv2rJEX4zeCfDMl18AvjXPrd5qGh/tqfA/wjHb6YfH+\
n3PiTVrrU7b9onw5p76FB8U/D91NdPHqGtWfi3SLy60HxFHb6R2v7bH7H+hftYfD3TdMs/EWk/C/4v8\
AgnWV174JfH9vAtn438W/AzxJqUtlY+J9e8G2k2taY9rqF/4aiu4ba5S/t5tE1+30Pxhpclv4k8NaDq\
Nh8b6n+zb+2V+2Mn7Kf7TX7Qnw4+F/7LX7TP7MPwm8SfED4S+CvCPxh1vxHqHh/wDa48V6f4YsfE/hH\
4s+K/BGgXtnffsra/Y+HbnR/EOg+H9b1PUb3QNWmjk1i7u5Yv7M/UT4L/FBfi34Dsda1bQR4L8e6ULX\
w58XvhZdakNY1f4S/FG30bStS8VfDnWr9tOtP7XFoNXsrjTdXitY9O8S6Dq+k+KNDe78P63pV9dEsJh\
K9LEcMZtTeNwOIpNU5ScourSUn7sakIwdLEYa1OVOpCUa1lTrwkqkajh+s4PiXPsnzHKPHHgDFx4a4m\
yrHRljsPRjRqrAY6pRjevUwuJq4yljMpztTxdLF4TEUa2WucsZlOKoSwGIwlLE/wA9/wC1n8Nv2/bHx\
VrnwI+OX/BRDwbp/wAPtS+CmpeIfC/xS+I3j34U/sZ+BPi14413UPEfg/UrDxPY+Hf2F/EcF54U8N6f\
rPhu11r4eD4iz3niWHxDYeIV1fTobo6PoHzdqMf7Q/gnwcPCXwT+M37I9xqVx4w0Xxu/gv8A4JqfHDx\
18dbHXrDR5rCx8Yad+0B4H/aQ/wCCg/gi10/wNrGktoenNd6NofiK5vVtG0++1Pw0Bpp1b0j/AILfa1\
43/bR+Kmmfswfsrfsh+I/20/iP/wAE4td0T9oP9ohDrfwg8I6T8Ndc+Lnwe8Xaj8FPB3hjRPiZaQeJP\
jH8Q9Q8KW+rauV8I3E+kaT5ukzy6P4v8Yw6VY+E/wACPG3/AAVX+HPxr+GnjbwJ+0x+y58HtF+LGt+E\
bT4O/DT4nfs4Q/DLxL4t8BeJVh8QeDfgtpnxtT4ReHdIh+HF14ch+GXjSWeGze0vbLwH8MNHsR4U1S3\
lFzqX3/EHgbxDwfwxheKuIMzzLB4PEYPAYuhg6Of4DE5lDBZlQq4zKq2IySeKnnkKWPwlOOLw+KxVFK\
thMZlNapWdLM8tlifFh9JDiDOuJo8LYXwt8MqdXG1vaYnF5jwxRy+eIdV0MPjcdhJ5RP6lg8HhKjo0q\
mEwuU4bDYPELFTwuDpqspVf0D8J/t2/tQ/s/wDjt/hd+0x4L+HHxU0jR9W+Hmnan48vfi38FPg98c9L\
tvF+q2J8Q6t46/Zw+Bvir4raxdabbWvirRJNNj8I6FrOqnQ9IfUX0nV7+5jtpf6EfCn/AAVY1rXfDGm\
+LLr9jr9qD4xeEfFkM0nhXX/2PPgx+0f8YNHCaZdT2Osjxhf/ALRH7LXwaj0iYagqQWSaI3iSQ3Gl6p\
Dqw0Oazs11P+R//gnP8XP2KvGV/o/wo8Z/Cn7F4O1v4RRaD8atB8c/Gv8Aaz1mcfEXRvFlv4i8a+O/D\
vhT4E/EiWXWfB+ux/Dn4e634k0C90mG18Kj4G2FxEmn2nhnRH8Rfq5+yjpP7Xf7KX7Xeu+Df2C/jXZ/\
G/4EeF/hxoHxQ/aT/ZQ8V+DxH4R8OaF4H1/wT8FX1DRPEPwd+G2prpvx41jS9U+I/iTUrbwloFj4y8T\
3Pwbm1TxBoXxN8SyWema7/O+H4j4keInUw3ElHG4GMKc50sI8JjcwwN+aThisHXwuBxLcIrWdL29Wap\
VZqnKPLJ/2C8h+jBjczzDgLEcAS4d8W8gxdXB1aPEdTO+Fck4hc40p4PH5JmuCzzijAUcNmNqtTBzxd\
PLcolTxGGpU8wjUpYiFL9ebT/guB+ynbeFfD/jfxFpniXw34K1geDbi41ib4p/sYeMfFfh7QvGOoaPp\
1trviP4MfDX9r3W/iCJdPTWIrnW9LsfCV9r2l29ldvc6UslrNEn1H8NP+CmP7KXxm0K78T/B3WvjP8X\
fDOn6tPoF94m+Gn7IP7ZXjTQrTXbWzsNRutFu9S8Lfs/31vaatFp+q6XNJbPP5yw6jBMyKk8efof9nX\
4/fDj9rH4HfDr9oP4SXOq3Hgn4h6VdaroH/CQaXPoeu6XqGlatqPhzxF4e12wLyLHqOn+JtG1jTbxrW\
e7sLiTTZJ9Ovb6yktbybyj9qrw3+w3pmn6H8W/2vPhD8EPGGp3mseEvg/4P1Lx/8DdD+NXxI8QeIfE+\
vXkfg/4XfDzw9Z+Ctb8R+MtVudY1bWLu00bRbO7mEU+oal9lS2jvbiP7SFXiWjl9POKPFWV5rldajTr\
OpicG8NT5Jx51XhisPjFCNCcHGUVOhU3f75JxPx7GYbwQzXizGeH+Y+AHG3AvHOX5listeCyTiKlm+M\
hiaFb2EssxORZrw88XXzKjiKdahUq4fNcJGMly/wBmyqQk5fjX8Qf2iP2S/wDgnx+1Z4l/ah/Z+8VaP\
8QdO/ab1Xx5rf7UnwY0f48eE9H8feDfF8D6d498Z2/jb4K/F/4uaDqng34iWsGkfEnWfDFhqXhyLWtC\
8Xy+LvhJqFubj4r+Cf8AhVv9Ieg+KNE8U6Fofinw1qFn4i8L+JtK07XvDviXw/f6dr2g67oWsWMWpaP\
rejapot5PDqmj3enz281tdQNJBPFcRyRyMjqx/mW+IH7ff/BDpbx/B2kfsv8AxD8KfCP4iate/CvV/w\
Boz9nT4Kal+zR8OPHehX2heFZ/ih4J8S+LPhX4y8F+OfHnw80rS/H3h2Xxb4SuNFv4bl10y+XQNVJ8P\
3Nx+yf7O3/BQn/gnj8WNC8K+EPgL+0X8D9K0+y1bQ/hP4A+GV7eW3wX117y2s9E0zwr4Q+H/wAKPiBp\
+hanf6SYNS0fT9KXStLksJZozpti73FrNbw/N8EZ9lFDM85wS4lyWeCxVSNWhgsFX5PZV53eInQjV5Z\
VKWIk41uaE6tLnm3SUIy9/wDZPpReFXiBmvBXhrxPW8CfEzDcR5Fg6mBzTiXiXK54j6/leFjSpZPQzK\
vgZV6WDzDKKVOrlvscXh8DjVhqEIY2WIr0bYf7jubiNAbqKObz4UIJe0uo1kg3B5InkNv8owpKk4CsA\
SdpcGyt9ZsoYXVvhgCN0yK2CMjKswKn2IBHeuG+LvxL0L4L/Cf4n/GLxTaatf8Ahn4T/Dzxr8S/EVjo\
EFnda7e6F4E8N6n4p1e00W11G/tbe51aTT9KuEto57q2heZ0WWeFC0i/kfov/BVf48DxndS+IP8Agl3\
+2VpHwrk0nX9fGq6J8MPjtr3xcZbXxrqXhPwv4bn+GWofs8aZ4btfiFe6JFpPibU4U8fS+HNO0C9mjt\
/FOq+J7NPDV7+g5rxPkOTVqGFzPFToYiuuaCjSrVbx5lH3nSo1FTje/K5uKbUt0m1/JHAHgh4neJ+VZ\
rnnBPD1PNcryap7KvVq5jleA/eqmqrp0YZhjcLUxVSNNwlOGFhWlD2lJSSlVpqf2p+2v+zDN+0P8P47\
vwQdN0/4iaHqGh6jbazBb3i+JL7T/DFzqupaBdeCdb0zxt4ebw58XfDHibU38Q+BdbfV9PbTtZtbzRZ\
dV0rw54t8WSXP5d/8ErP22H+Gesn9jj9qH9qH4RfEHxPqWu6DZ/AW90HSfCngDT7WTx3deMtZ8I+APB\
2l6brsSx/CLWfDemaYngTSv7C0i98C6/oniH4UeIdN8NiH4TaZ4r/Tv9kr/goF+yt+2lqfi/wv8I/FV\
unxO8AnVJvHPwt8RHw3P4r0fT9N8Van4TfxFpOveDtd1nwz8SvCct9Y2U66z4R8QeINLit/FGjteXlt\
PqlpBJ8L/wDBUn9mTxJ4V0q//aj+DWq/D3wI3guzsdT1lNX0PxxCJ9fuPiLp3izUfC9/qvw/8daVqGl\
+CPGvi5tBuobrR7d9Y8D/ABW0Dwz8S/DE3h7XtS8V+O9I8fHLC51QwXFXC+Ojjcbl8aipunNypYqi2v\
b4SsqdSKlUTjJUo1k3h8StYU5ObX33C7zTw0zXifwD8duG8Xwxw3xdVwssVDHYSlSx2Q5jGEv7L4hy+\
pi8NWqUcJONam8fVy6UI5zkskoVsVRhhoy/Ur9o/wDZc+Df7VHgTWPBHxW8N+dc3vhLxt4O8PfELw68\
Gh/FP4d6d8RNHj0HxjL8OvHcVq934Z/tPSYLe01ezUy6Vr+nRvo3iLT9X0S5vNNuPwI/4KOfsM/GLXP\
2dbvw18UP2Y/Cv7SXjH4SfCrRPAX7M/7Vf7GXw/uPB/xR8I2vhu8+D1tonw2+Lv7GNh43sbS78H61rM\
vxKtYNS8G6r4t0nwZY6peazpXw98PRzXcE2X8P/wDgsp+2j8P9Q8MfC74gfsv2P7THxAfwl8LdBn1Hw\
T4/+Enw31q/+LGoaXJB4t03T7/4O/GD4yeGPjTZ6je6j4Z/s/UNDg8EzLqf9pWUng7TT9ms7b7X8Vf8\
Fer74TaYviD48fsr/HbSfCGo3A0DTrn4YfB79sqTXn8R3lvc31pBer+11+wx8EPDf9jHS9N1hpPsHiy\
/13zo7f7L4furD+09S0n53PqfCHE+CzCnm2HxuQYnHUfY4iWIyzExco/Y53LDV8HiZUXyzp1qFWdfDO\
yo4jDzk7/tvg/ivpCeBnFHCGJ8P+IuF/FrIeG8yWPyqjlXGuUVlRr88PrUsJTw+c5dxFk1PMISrYbF5\
dmmBw+V57TVV5jk+cYWjFL8ffh58Y/i/wDAb4j+OvjD8evAfw8/bO8DfHz4efBjVf28/wBmHwlrPw//\
AGkvF3wv8I/B+Lx79i1f4r/Dn4h3UXxF+CfxD+CfhXQ/hLoesW3j7TfGeia3rd5q9z43+KuneM7vR5t\
P8P8AgZ4N/Zy+NX/Cr/FOifti+Lf2Tb34Cfs8/BP4c+Fv2mPA+l3WkeIvBHxr+IX/AArrTvi74a+JHg\
/wr8d7DUPh3+zzo3iD4neL/D9j8RNO8CfDXwjr/in4va3deP8Ax74l8TRjWfib+vHjH/gsR/wS3+Plj\
peoftIfAaw1nTfh94w0/wAGpD+054T/AGNPEPxF8AP4+u/A1vqPiHRvgL4l/aE1L4jax4bktdY8L3eo\
XPhPwfrD3dloUk0cV6+l3Edv8vS/AP8A4IN/tGad4h8C/sfap8UdA+Mdr4S8Y6haa58IvgN+2l+0rqO\
m6PrPhbWPh/Pqvir4U/Ev4ReLbS48JWureN9Fuze2Eeia7p+q2elTaH4q0PUhBeV+TZpw3SjXweGwHF\
GU5/hKLq1qWGzPFVstxtadaaqynhZTjQqSjLFRqVXyYqny4iM6kcRRqV8Tzf6CcDeMWYV8s4izjibwR\
498KeIcxhl2XY7POB8hwHGPC2XYTLsLLA0aOe0qVTMsHSq0sjrYTL4/WMixjnlFbDYTEZRmOEynJZUv\
hL/gmN4l+I/7O2u/CD9vz9oT4H/EP4ifsx/Az4efGL4OfBfxfoFrF4Tl+H9ncXnxL8d+M/Hmi61qy6L\
4W8ZaTH4z+IvjrwdbWXjDxRp1/wCI/EfxzTRvAEXirxD4Um0HR/1H/wCCs+s/sc/tGfB0/tj/AAf+LX\
hLRf2m/Bvwl8N2vw78JfGfUPF/wL1/42fs/wB3420f4gHX/ht8LfjX4g8FXnjS0TSr/wAbzeHPEWmaX\
r+leIYtT8RaDpVlq3i+38Map4Pk8If8FOtc/YAHhz4Z/EL4sfsmftRfs0aB9m8JfDzxB+zZ8Z/Afifx\
B4G8C6OfiJJ4S8G6P4Q0HXtQ8XaANE+E3w4+HGg6JoHifSvGtnrHij4jNf8Ai79pDRrOKOyT6F8AfE/\
/AIIj/tCeGNc0A/sm/Cvwkmoj4p+EPGUtn+x1YzaZ4H07wDqOkeGPiL4su/2mf2cvBmueDPCPhPSNM8\
beCdYuvG+j+PF0rw7pXjzQ9bu9e0k3VvMnocNYXCYLh6twnlvFeCpY1xjVnHMl9VxeEzCFOlSpYrBYu\
jUnCpyyhFYR/vZRpUKcabq0o1EfE+NedcS8S+MeXfSD4z8AuJsbw5RrVcFha/BFVZ9kHEHCGIxmNx2P\
yLiTh7MsLhcThZV6GIr1M+jFYCnXx+aYyvi6WBxtXC1Y53/BPL/gtD+zl4u+DOheAf2jPjJdad8ZfBm\
kh21PXbLV/Fnibx74ObUru10vX9V0vwZod5f6ZrOlr9i0jVJ9RikXUJobTVY9W1OfU7r7N+mfhv8A4K\
E/sfeM9K8T6h4U+N/g+/u/DGni9OheJNQg+FGq+ILma21Cex0nwxN8aZPDdjq+oTy6dJCWF4lraSXNu\
dRubKGeKVv5tP2uPhR/wSw+Fv7S/wAKfjDfftC+AP2lv2Pfil8QvFmlfG74A6f+0p8S/jV8Qvg18WPi\
Z4Zt77Vf2p/Bt/4A+Mp8Ra/o2sax8N/Ckfj671u61nU1T/jwtvEN3eeHdP8AC/6l6R/wRP8A2IfGvw3\
8Mjwj8U/EM3hvVfCfhN/CnxV+HPww/wCCfGifErV/DFtpulyeHte0f9o/wH+xvb+LtZOoaJbWYudZh8\
STT6/YahOl/e6haajdC5/UeHuLeJcyq5hl+IybBZnmGUNQqywOYU/3kpQpyp4j6vUppUsLieafspRxF\
apGVKpSq0qc48r/AIU8Yvo5eDPB+C4R4zyfxD4n4I4R8RPaYrAYbifg7GL6jSp4nE0cZlEs0wWLlUx2\
eZP7PD/XaFXJ8twlejjMJjMDj8Zhq6qLD8W/8F1/hh8OvDcWr/Enwh8NfBfiPVZLeDwd8NYvix8XPiP\
488eXOoeGNL8TaRZ+GIfgv+yj4m0uO+uTrFppkkGparp82layTpuuppVwUD+ffH3/AIKv/wDBOP8AbO\
+GGu/Bm88Taz4R8STbvE3wr+LuveNf2e/Aj/Aj4yeG9P1HUfhr8ZfDnj/XP2nvDcPhLxboevRpPZFfE\
GkSaqHm0A3MsGrT2lxp/Fr/AIIOaH4n+E2ufCXwB8atP1LwvHFrGp+DNQ+NunfH34gfEKPX9ettHfXL\
7VtX0f8Aag074aQaretoel2Ftq8XwYuG0vTtF0W6n0zXdc0SHVLr8of2ev8AgnPN+1N8WPip8LfiXb/\
syan8f/g3psOk+LfhB4P0X9mn9ijVvDtnofj3x14b1fxdpHh/4WfsHfFDRvjN4NmvV0CyuNchl0TVND\
1u3vNG1K11HRZvB/iDWvB4k4u4tw+PWQ4/gyjVwmfQ5MNTlWdWNWMYf7XTq1aMnJVrNOjTo0Kk3Buq/\
dp1HD3PCPwd8C8XhanG3B/0iMTgeMfDV08xr4mWGq5R7ObxUYYDF4Gjjstr0FQwk3H+0nmGY0KM1yUq\
U5zxccPD9hv2F/8Agtv+zV8RPhmvw6/ab+Pvggftb/Bu61nwp8VJPh7oWo+NPAXxItNJ1JrPRPil8PP\
Fnwdt9d8OeK/DmqaNNoY1O60u5tbW18Qi8EGkaZpNxo8dyV+KX7W3/BFT9r3wV8Ovh7q7fCb4N/ET4h\
aD5Wl3GofAD4zfH7xd4z+K+heCvB2v+LvFNt43s/2jvjpY3useOrqDw/qF/o/hj4VeDribU47/AMVXC\
jw8dN0Sw1Yr5+Xi/wATcL0sNk+beHeNzTEYWnCKryr13KpHli1zz+prnqxUkqs3ZzqJ1OVKcW/3Sj9A\
vwj8a8Xm3H3A30luHMhwWc4vEVMRlOWYbh+WDy3ESrT56eEp4vjLK62Hy+tLmrZfhnhV9WwsoYbnk6L\
t/c3HNDNu8qWKXbjd5civtznG7aTjODj6V8dfF/wPrvwb+I5/ai+Bfw50nX9d8Zat8PvC37Xvh3S7a8\
j8SfEf4H+FItc07S/ih4X0jw34U1LU/G3xw+H0GvT3WmaZZAXfizwnJrXhQWms69B8P10L8Nf2Pf8Ag\
lX+yb+0L8FvBP7Sn7AX7UHx2/ZYm+JHhbQ9C+PHhD4N/Fv4geFLPTfHvhe2Oqj4c+M9G/Z/8TfCq3vf\
FPhfVfGHiuKHVNZ0a5udV0vxLZanpTW2i31o979Sn/gkL+1l4LvLHxp8Hf8Agrd+2H4Z+InhYazqHhz\
/AISbxv8AEj4peDtfvb3wxrugx+HfGXg79pD4qfEjwvc6BO+sJKbubwjqV9pl1Y2upacourREk/oSrj\
fD/PMsWJy6rxTUqTpxxOX4yGS8NywvtXhlOlUdaPGlTGUqcpzqYeq6eW4ipLDymvYVVVlQP85Y5Nn3h\
TxfxBw9xHisBhcfl1XEZPn2QZg86w1TEU6WJjHE5fjoUct9gnTxGHo4vDVFjLYXG4bB4/D1YYnC0KsM\
H9vr/gnF8evit+1D8GP+CqX/AAS2/aI8OfCX49D4eaV4R+L8Xh3Q/AXizwl+0/8AAGbS7nXdH8QeG7e\
5u9M0D40fE670D/hHdJ0rT/G/iPS/C+uWmi+DLqDxz8P28G2Os3X8m/7Q3xK07Vvh3a+G/wBpX9nvwR\
8Bfj34u8CeCPCfwy1a/wDhHd/EX4/fFj4sfCDSvAfjL4nn9ouym/aW8K6hb+JvCdxfaXb3l/8AEXSrC\
3v/ABZqHiHWfB1hFc6de+Fof3evv2N/+DhP9kdfC3wm+Cv/AAUF/ZY8NfAvxdqfxG0j4WyXHwz+HPwy\
8EfC/wCLvxP+Jmr+MfB3hjx7qth+xT4ujNnrfiTxxqFhoVjp2i+EPDeo6nBb+FtP1Dwtq+o+D/D/AIm\
+aP8Agpt+zJ/wXD/aE0mXwj+1L+y1/wAEqPE2k+JNdsLfWfin+zLceMLTxn8QtHtdA0i8l0270T9oDx\
/anxNaafc6L4fs4dS1jSVvPD97p1pPoc8UDBtQ/ZeM+N6niT4Z8McKcXcY5BnGZ8CZPjcnynMqOCz/A\
A+a5fQpQrYjLsDiJSyGhi8xwdLGTjUyWeNoR+q4P6xg5YrLJ1qNTB/HY/gfhTKOLsHUzfKK/FnhbnWP\
pY6dB4vLcLiMyyihj4KvTVf2uYYLLc5dGm4Vo0vrzwWOVPFU6WMoRo1MR/PtoP7RH7KPjrwVZ/Bv4i/\
B34y+BNI0PxhpVhe+Lr34zaNoeoalo8Wqax/wqv4jePtc8NfsweJ/EnjE6T4Qv9ah0YavqHiXVfCiw6\
/ovhVbeOKS3k+vvCf7S/7Yv7F/w++Evx9+A/7WPh/xxP8AD/4ReIvCXgjS/AvgBvhrqPxA+FGmeJ9a+\
H2neGrDQv2ivgFoCfHDULfxxpHivUNR1CGz1aPVvEfhKSwsr2/8apNYeG+s/Yj/AGqvjx+zVY61+wWf\
+Cf2nftVfEPWPiJr/jS28B/DXxh4K0DxL40ePwv/AMJt4z8LeJvDfhv4VeLIbr4q6Npngea6u5da1PW\
LnTZoz4dubyCbw1Y6bL/S38Cfit/wRe/av+H91p/in/gnh8AfDX7UuueDr29+LH7KWgfse+EfGvx08P\
eLtZ8Navrupab4Q+JXws+Gk1h40t9St7HWrrQfGGma1psbpaTT6lN4d1zTNd0zQ/5t4j4Nx3Hv1viav\
i8vx1KjiYyqVauLhhOIIZhGUKlXF4vAYLHRxTSnUpuOdzw1GPt8RhF/suJeGpv+jct464F8IMVR4dhk\
GccX8HVqNTF5HWz3+x+KcBXyrG1sSsE8vhxTwvUxmUxjPBv2+AwmYKCxuCzSlVp1KWIxfN6l+xN/wUX\
/AGL/AIE/BfQfCep/G/wN8WPHXxH+Ifjf4v8AxU+KnhTxh+xLonj74jeNfjh8Q9U8a658QPFn7PHwZ/\
ai8R+LF1bS9B1/S7TUrSx0XUNS03RvA6p/ZtnZ6amn2fwr+0B/wUn+CP7S/wDwUY8Gap4p8A/ET9pD/\
gn3+z/c6p8LdH8CeFPhxrPxA8L/ABW/a+8Z/Cz4wDwo+u/AvxP8HmvfHvj/AFHWvD3jPwF4L0TUntYI\
dc8Kr4n0jxDZ6bf6rZan778b/wBlP9k79lH/AIJJaB4x/ae+CejXXi3w34bfXvA3wX074mfGH4W+CPE\
fx/8AiFf+Kj8Jz4r+Cvg74i+BrLxN8StE8JeKrSy8U3qWx8V2XhHwBqunWV/daZoNjDH/AC32HgD4Ca\
N8CNO+N9g2vePvjh4f8R/D3TtV0bW/hppOufB3whrvibx58Tte8NeEvHsfjn4ZazoPj22svBf7P0mrS\
aHf6iln4wP7QNqltZQQfCvxhZ+Lfx3xG4qx3DU8k4QdHCYfB5bGlmE4UcZKtOthMHf2WFxFLGUV7V1K\
0FiJReIq1sSsPJSlSlL25/oH9C7wD4Y8aKPij9ImGZ5/m3EXG9XHcI4avmPD1DLcJl2fcSezePzvKcw\
4ZzSby+GDy6vUymjUjk+Ay7JZ5vRlQo4+nQ/syP7z+IvBv7OOufta658X/wBo39pvwt4a8IwXXxF/Y/\
t/AXgj4i+HbeH4O/AvxV+wr+0na/EbwN8FvgpL8F9J1Twh4P8Ah340+LXwI+C/hq1TRZdX1f4qaF4qj\
8ReFNO8Y+LLLwfp34lal+yvZ+dpNhpniK31XxhrPw9+Mfie2+Gfwo8efBr9ofxVo2pfsveDvjjbfHmT\
x9N4c8f+HpfClpdfET4HvqXhWDTdL8R2useDPGt0/hzXfGXifwrLoviL6H+GWjfsWfCX9qvw34y0X9r\
T4ieK/h14N+Gt98QPCvxQ8JQ/G3wRcfAD4u/GT4nWHw48f+DdYufD3xS+CfxL+PHhaw+HfjPXdR1rWf\
hm/hjX/EdxqMWv3PgifQtK8T+Hm9S+G/7HPi3/AIKXftHfHzSvhX+0UqWXjDT9f8X+GPiR4htv2rdU8\
I+N9O/Zf8QQ+D/CUV98VP2jfiJ4l8eeF/inJr2u/sxeJJdNtdf8W/2D4P8Ajest1q9pe+F9I8Aah+f4\
7CcMcT1MJhaWXV8Xj8VmOImqOFxWBxGJq+2VBzqe19vCNWm3QjhaFRVIRpyrOvVWKqUPqr/rvhXP/HT\
wOw3EGd4zjHLcj4UyLg7J8PLMs94f4qynJsB/ZlTMYYXCfUVlWKrYHHRjmtXPs1wk8Jia+Lp5dTyrAP\
IMFmn9vQ+fdX/bM/bf+B37I3gn4WePfiF4K+M/7G/7RXhHwBpvjP4R/EPxlo2sfGn4D/CnXdQ8P2/h7\
xR8LtY+JPwt8QaBoCwWfwd8WeG9BvfDmu+N/Dnwr8UwpZeLvCfhX4rGw8NQewfB3/gql+1hD8HdM0TW\
7vxB4h+CHwDj0Xwbp/gjXNB+GniGy+GXhv4f/s66ZZaLcS+OvAmmeD7ZPh9rPj9JdL8MW3xAudM8bSl\
NN0nwprnxV14eMdNtvnz46/s1/GH9kuX9on4bfE/wNb+FPF3w/wBPHxR+PHxB+I8XgDWvg98cyNd1TV\
/g/wCL/wBlL406N+zJoGsfs3anqX9v/HW9stMh+KUPiLxVH8OfEmiagqavZP4P1X4Y+Hn7QHxmdfAV3\
qnwx8AfFbxjptz8Y/FUHjvV7XVfFPxMudF8D+HNP8Z+IPht8Q9M+FfjLSpvFnwf1Hwjqlz4UgPi7TLv\
QtP+HU+oeHtD0zw7Z+GdfVvXhh8zy7EOTxeYYDC5dhXT/cVsxoV6dKjVqzlKMq2JdevTw0406NXBU41\
af1/EvCzo4WjFY2p/LfilQ4K8RcneDznhLLuL4ceZysbUxuV4vKOTCY2plFDEUHjMo4YwmEw0MTn0qG\
LxGWcTYNzzzH8N4XAYl4PianLMslwP9OGg/En9gz9s7wlJexftEfAv9l79p/w94h8FftAfCTxV4o+NH\
ib4U/Dj4yeN/gT46+JHg/StG+L/AIgsvEPhLXr68Tw8NJj0rU7OHQfHXg/QvFsGueDXeB/E1rq/9Fv/\
AATg+P3in9p/9jD4NfGvxnrf/CUeIPFH/Cw9Hm8Vy+ENO+H+o+L9O+H/AMVvHPw50Dxj4h8D6L4j1bT\
/AAl4t1bw/wCEtL1HWNP0zUbrSrTVdTvIdLZNPS2jT+Z34wf8EmNd8cWPwV/aB/Zj/YE0DwJfaJodj8\
WfFmq/8Lf+DX7SHwW8d3z+NNV8dweJfhx8FPDnjhtJ+IMGo/DXUBb6MP7N1CxCano2laf4cvrDw/FL4\
j/sa8F+LtF8eeFPDfjPw5djUPD/AIs0DRfE+gaitveWaanoPiHTbbV9F1SKz1K3hubSG40+7gkEVxDF\
PEWaKaNJEdR+ueHNLNMdmmY51ipVJUo4SjRq4ieV4/KXmderP20MRVwuNpYN+3wtKPLUrUcF7Co8d7O\
FaNWjiKMf81PFvxV4Nzbwwyfwm4ewfEOZ0uGs6WOy3EcTYjKsRjeHMBDB4nBYzh/B1sFhXiK+Ex1eeB\
xVVyr5dQw9TKqVKOVTc44ijY8U+E/CvjnQb7wt428M+H/GHhjVPsv9p+HPFOjad4g0HUfsV5b6jZfbt\
I1a2mt7vydQtLSeLzI28ua1jlTDorDx/wD4ZN/ZY/6No/Z//wDDNfDr/wCZyvoCvzJ+PP8AwUj079nb\
47+LvhR47+C3iq78M+E9J0/xSPFXh3VNSvfFXiXwI/w21/x34n+IfhrwfqXgy00e58E+HdQ8N6rp2vX\
tz4ttPskdndX8Md0mnarBYfr8pRhGU5yUYxTbbdkktW23okluz+XqNGriKtKhQpSr168owhCEXKc5ya\
jGMYxTcpSbSjFJttpJXPqDXf2Svgz4g0bU/Dl1H8UbTwvqtheaRN4N0f8AaB/aA0LwFbaDe28tjN4X0\
vwBonxPttG0bwcNMmksotGs7G30yCwIsLe1itFWFflLXP8AgkZ+xN4k1L+0oPhjoun28Vjbac3h3xf8\
Ovgb8f8AS7C9t7i9uLnVdEuP2p/hH48vfDN9eQ3tnFe/2ReWNpfQ6Lp7XFs81sslcnoX/Bar9iTX9Kt\
dXh8deD9Fiu/P26Z41/aa/YR+Hnia28i5mtm/tPwf48/a303VtI3tCZIftdlD9ot5YrqDzLaeGWT6U8\
I/8FA/2U/iPrE+m/DTx141+IWvWOmy6nf6B4G+Bvx78V6quiW91bWk+pT6Zonwxnlhs4bzUbNPPKKgk\
vI4S4aZAcqNbBZhSdOFWli6UuVq0oVI66xvZtWla8W9LpNNK7PXxWXcScK42nUxuBx3DmYUpVIQdWli\
MHWjOHuVoxc405qUFPkqRWqUuWS1sfHMP/BDP9kHw1rZ8Z/DtNV8NeNbPW5/Evh2U6P4a8HeEvDfiC6\
1KTU/7Z8O6Z+zXpvw213wRqVhe3Et7ocvhXxN4cfRtTtLG6ti1tatYT/PvxI/4N5/gj8RNdvPFP8Awn\
mkeGPE2uatrev+MfEVrp37UHxA13x1ruvXi6je614p1f45/tr+LbifVjqEmoTyXNrJaTXk2rTy6g946\
27QfslY/tf/ALM1xPqtjq/xl8HeAtZ0S/i07VfDHxdurr4LeMbKe40nTNctJpfBnxbtNE1U6dPpOsad\
Nb3i2ZtLhZyIZpGjlVPxv/4Kxftw/Dr4k6p8Cv2KPhH8b7f/AIV/8Y/HHw/1b9t74vfBzx3oT2Hwe/Z\
G8V/E3w98H9Si8Y+P18Palovgzw74h8S+LLiK81K51W1js08JQ6Prtje6P4uW1u/juLqHCmUZHjcyzb\
h3BZjRpSjy0amGw8lVr1Zxp003UpyUbzknUquMvZU1OrJOMGf0R9HbM/H/AMRPFPhngnw+8Y+JuDcxz\
CnWVbMcFnWb0p5flWBw1XFYypGOFxtCpV9lhaNSGDwEKtL67jJ4fAUZRrYmmfnPp/7EPwS8HfCfxR8M\
PhR/wVz+H/ww0nxx9ouPGXgXw7/wVl+GFr+z74lvPEFnpei+O7XWfg3pP7JNjd614f1TwtYyaSINQ8T\
3t+lglnDqGqastowufVfg5/wSF8RReGfhBdfAvTv2XvifoWt6j4mufHH7W3g/Wvhb8fPCfirwHpmu35\
uPB8M/7RXhf4ieELXxX/bWk6npL6r4W+CKX2iN4a0eN/EWpJqHjLThleMv2c/hZ+0xdfATwl4V+Ffi2\
0/ZH+Cni39huDwp8Rvjb4k8ReIv2jf2ivgV8Wf2jfB37KPhabXtS8Z2Nt4m+Cf7PPjay1P4ra58NfD3\
gnWdA0fR4vg94k8Q654A0l/iP8PL3QPxs8Vfs3fGT4K+KfFPx2/Y38beLfFHwz+E3i34u/DnSv2ifhB\
4/n0/Xx4p+DWnDQ/inf6FrfhmHSZ1/t74Z6pcfEaw0vwzc+Jbay+GHirUpZ/EviCDwP8AELVdH/C8bx\
JgMixeEx2J8M8tzjL6dNxpVMHz05wp88fa18JTq0akJUITjOnCtSVPmkm1Up0nef8Aq3wt4K8W+KeR5\
7w1lH03+N/Dri3FYuFbMMHxJ9VxWFxWMeEqfUMqz/GYDMsHWo5ri8LVwuMrZfmE8d7GjUjGeDxePpOn\
hv6GrX/gl9+3x4D8SaJd6X8efE/h3wgYbnWZfBf7FL/D/wCDHwu1bxPpV/o0tmvxY+EHwt8U/s6Wuuw\
61pk1zaahr+i62PFU2neGLXS/7W06ODSLux+Pv2pvh3+3X+yF8UdK+P3h7xTpfwE+IL+HvEn2L4xX/i\
fxvr/i/wCLHh63h+H/AIS1vw7478DfHf8Abk+P1rqnhrTbzxN4ZQ6ZY3TzCPSNN8b3e+28FJZaX7F+x\
3/wVF/bu/Z8/tDwR+1JpXhH9pv4NfDtvhB4b1z4tWfiVNG8deBbn4nj9n/TPB1n4h+L82kxeFNS8It4\
U+IWsanofjX4h3XhvwZ8S7vRPEGpeFvjZ4i0yxsnv/6G/hL8Yf2XP28vhh4f1rT9K8H/ABF019C8CfE\
fVvhJ8V/C3h6+8ffDGTx54ev9S8EX3j34aeIo7ubwnqGoeHbjVptF1Ly30/XdKuW1bw5qWraFfW2o3X\
6HlVLgHjbASwOW0sRkGdpSq0FUnXpY7CYilzwhicNN1pRnKhOMpJ0asotRftEoy1/hjxpwf0v/AKP+a\
PO+KOIcs8ROAqM6NCWY4HBZRm/DGY4bErDYqOCzbAyy+jOjRx9CtQo1qGZ4TDTr069XC0K03KZ/Lj4x\
/wCChHjr4wfD7WvD3xN/ah8Q6BN4Rg8J+L/AHxT+IXxM+Bmu6LD8TtOu9Wj8M+Kde8D/ALDX/BN74ja\
7+zT8RtI8RaXp83iT4d6p8UfD3jnQbTxgnh0eJLj7XcasxX2Z8b9X+Cf7DXx4+I3wD+MXgT9ozx5+wV\
eaV4Rv9O8NS/EH4ueHPA/wk1vxBZeJPH+maV4Hs7L4n6X4Z8Y/DhtU8LauynVGtNSS98J65qKtLJ4O8\
Q6vr5XztTgbF5xVlLNeNXgM2wKVCvDHxqVcQ3FudOSr4fNsJGthpU5xeGlOn7TkbVblr+1hHvyL6SHh\
VmVLGVqH0NKPEEJ1VP8A4xTMKGX5Zh+alSjKnLA43gfO69DFzqU51sSo4yOGcqijgqUcHChKX3B8eNA\
j/wCCd37Tetft++Cbfwn4Y/Y9+OZ8I+D/APgoN4Q0Twl5/i3w14+l8QeItF+GH7Unh+0i1mOXUHbxv8\
RNJ0vxhp2iWz3k1tq9/wCIR4d8V67qk+p6H+wWga/oXivQtF8U+Fta0nxL4Z8S6Tpuv+HfEWgalZ6xo\
Wv6FrFnDqOka1our6dNJb6rpN1p9zbz21zBJJDPDOksTsjKxpeJtA0PxHout6D4n0fSvEnhPxLo+o+H\
/FvhjXtKs9b0LxBoGsWc2m6rpusaPfQSQapplxp9zNb3lvcRyw3FrK8UsbqNp/I79nP4qah+wf8AtOz\
/APBPv49fEEXPwR+Kog8Vf8E3PG+t6V4pXTNH8KXev63pup/sceI/ih4s1q7/ALa8WeFg/g+z8HwXF1\
qNxdaVq1haXGrWdzrXhLwjbfrMvZ8J5nFJqjwxn9d8t2lHBZjWk5ShzSlGMcNjqjvGMY+5j6krtrGRj\
R/nBwxf0geB6uIjTqZj41+FGVwVVQhKpX4m4PyujTo06nJSoVKuIzzhTCKMK9arWUcTwjhKLUKU+HK1\
TMP1R+LHwn+HHx0+HHi/4R/FzwhpPjv4c+O9Jk0XxT4W1qOVrPUbNpYrq3mhuLWWO40rVrXULazvNP1\
Czmt7/Tb+wtr+wuba9toJ4/xA8Y/H3xv4r+OnxE/Z2+MvirwxqvxJ+B81/F4HuNK1TbqvxX+Bc+u3Wl\
+GPjbr3hyLQdJsdI+IUmt2moeHPGsGi6bZ6VD4h8GC902ysfDeteGEn/WT4h/tLeBNO8LfFa18H+Ift\
HxB+HniC3+HureHL7SdY0PXfDni7XtOk1HQ9TuNI8R6CrXXh+XRI77VNL1PyJNE1yHR5Y9Pv7gbmX8U\
fiV8CPFnxtvPBbfCCLwVpf7RfgvXjqnwQ8beN/Dl/r+ieHNV1OOPTvGOh+I/7FU6hZ/D/X/Bf9raT4g\
ntFmmsLK8Gu2ltLqui6Y8Pr1+Sq4ZzlU4YurSTp1FSlCSxNKlUmp0edXjKtQqe1dBSklCs6tGUqUa1a\
a/KuHMwoVcJX4C4trTy/JcxqPE4LEV1VcMmzSvRpRp4/2XxU8DmFKnhMPnToU51auBo4TGwoY7EZVgM\
NP5k/aq/wCCXuqan4Kv/wBsT9nvwdpfhX4leI/H+jeJNV8eaF4vuPAfiT4a+I/BF5qI0H406BrdvrVt\
p/g3w1feM9VuJfHuq3QiuNNk+H2ieLIXsIh4n1yTxL4S/tgfFTQ/EHh//goR8M/FWk6F+0B8DLDQfCX\
/AAVm/ZO8PfDrTbHU/wBrH4FN8SHtbL9oD4beBNP8TQQeOvizHpni6ybw7d+HrjRbfRPib4u1OG+0WL\
wZ8VdSvn/rE/ZS+JPgz4nfBTw6/hi20fRNb8DTX3wt+Lvw6sfEGleKdR+Enxv8DNHpPxZ+FnizWdI02\
zt9X8S6V4t+3rNqUNnb2mvW91beItME+k6vYXVx/OH+3r+zb8RP+Cc/xll/aL/ZU8E6PqfhK6+Fdx4T\
Nv48vdc8QeFPGfhrxB8VLPVviB8CfGvhfVPijBD8Wr6fwpcLYWuly6bLJeeD57zVbHSrvxt4Rn+Imje\
BmEcTleYZf4m8H+zxGY5ZSnPEUJUI4ilmGClQqU6vNhZRXtsRHDVK2GlCTjWqYStXw1GdDErD4jD/AL\
34Z53RzXLcy+il4xU4ZTTxWZSp8OZnjMRCjHhriDEV6dGeCxePbq08NwrnNb2dfMKmHvh8HmVDL8/Tr\
YWjj6GO+y/+Cp3in4C/tTfsIfBz/goP8MfiTbfGn9nz4U23iz4m+DtH0S/g134WfETxF8UvA+v/AAi+\
Cfi/xT8LvEelCz8WeMPBP7TesfC9tU0PxQLaHS9BX4h+HvEGg6teXNx4Zu/h7Vf+Cdd5+yZ+xl+wfb/\
tN+Hvh54s8YaV+3t4K+Mfxp0YeHdC13Qvhd+zN4M+FXxf+On7QHgPXFt/Psvirq0Xw5+F+v6n4wvbKz\
vNU8Vw+EPD/gi2l8V6P4I8BonU/s7ftS/B/wDYl+MGuaB45+Nfw98Z/wDBHf8Abl8XfE3wV4P8MeJbH\
wv4+8K/sYftN61r+j2PxC+EfxU8S6L4r1jSPCn7P/iCTxbe2vi/VtSvfEnhLWvFfxF8MfETRvEU3h34\
i+LtXtP0Q/br/ZI8bSxfs6aVo3w01b9oD9hP4IfHAftDePv2Zfh94c8I+Ifjh4Pl+Gvw48eS+Dvh18I\
NH+I3iqy0H4kfsxX2u6m1lffDp7S48R6Vaaz/AMI94Fnl8MPonhnwh4nHnBeUZoqniVw7gqmaZLxNh6\
VDDwcqmIlgMbTq4OWPweMxCweGhjqmBwzwCq18NhqdN4Wph83o4L6tmlF0P3/wC8duL/D7B8J/Rl4qz\
z/iH8eCs8znMsRWxcKeDq4/AU8uzeWX5Vgp1cRShlua/wBs5hnNSVPF4iks1q4nC5RUzTAyyunhc2/i\
W0L9m/x1Jp3wy8W+N9G8WeCPh548+LXhf4Xat4t1XwRrGhad4SPi/wALeAviH4V1278Z/FCTwt4Ek/t\
v4b+OV17Qra78b6d5+l6FPrGs3Gg+HrrTNcvvrD9ke38I+MP2lPhXrX7LujeLPBfxWsj8Tks/hzceJ/\
jrqupvolh8EPiYulanouv/ALPfivwx4y8VNp3h3wBLrfxG1zw74k0DXdd1X4yvovw0+COr6VoDeF/En\
1t+1Vo8H7JP/CAePPCfjH/hvL9hH4jftDfGg/HH4c/Gjw98ZPCfjt/2ntB/4W74H8b6T+0lc+O5X1L4\
Q/tZn4OfGW5i0fxJpll4O1DWLz4Y6Z4xvPAc0/hmw1bVfim8svg/+0T+zV8Y/jD4i/ao1rwb+2Zq/wA\
Zb/4m/Fb4DePLzRNG+F/7SureLPiV4T0Lwx8X/CutJo/hXwv8KNa0GH47/Fp77TLu98TXUWnaTrms2S\
eGfDkuoi2/keOT0MjzSGFpwpV8wy9wxdTD1KlHmrU6EKOIpyweNVR0ZyrQk3ThQlVdZrEJ0KkqWEo1/\
wDd+fiNmnilwNic9xVfG5ZwfxfDEcP4POMLhMz9lluMzbFZhlGKpcScMTwtPMMPRy3EUY08biM2o4Cn\
llKeU1I5rhKeYcQZjlPtf7Qmr/8AC1v2llvvif8AtJ+GfGf7R3ir9rXwl8Jfib8BPiT+zb8FfGOgeJP\
Cvje88AeH/hu/xW8UaYfBl58WvBWjfDf4Q+CG1XwzrHw/8FeIfA/xG0dbO88IfD7xlqdzrsP5op+yj4\
l+InxSTU/2fPDknijwNqbeKta8IeFfhL/wlulG5+H3hr4lyfDPUdZ0XwR+0Nrepa1ofiXxDrNhodr4G\
0+81jVdJ1Px746tPAXhm6vPEcup+ErT6E+Iur+Mf2kvCn7S/wAT/wBoTUPEfxA+IvwP8H/shfBvT/jj\
8TvE3ie88RfAjUdf8Q3mmfEPT/iP4bbwBoWp/EHR7fV7/wAYaJrUl9o/inxdot8thb2cPimB7rxHa/0\
2/wDBFX9lLRvjv8Hvjd+1b8bPA7ad4M/aS+Geo/shfBv4Up448ZaxYeC/2RPB+nx+APGHhfT/ABVF8R\
JryVta8SeH/wCz7+4nstI1aPV/hxqPiTTJLaDxZItfreU5djM/x2AyjLq0ozzJ1sc6tWeKdWpCNXE4f\
GYjF+1liKcY1nD6liPYTqQxDxtFKFH2NelT/wA8fEDjLhvwk4T4s8ReM8soVsNwZTyzhdYDA4XIaeAw\
eJq4DI834byjh54GhlOLr1cthi1xPlH9qYbB4nKIcL5jOriMxWZZXj8Z9ffsi+OP2o/2tvhOvh2z8T/\
s9/s3/BW38JeD9I8P/wDDO+m+IG+J9l8M76z0H/hH2+EnlfEO/wDDnw/8JXfhmz8Y+HLDXIEvrnw7rv\
gbV9Ig0a21jQrr+zP1W8BfD/T/AIa+APAvw+8O6jrN5pPw68G+HPBOgT6vPYXGqXekeF9FsNDsW1S5t\
tPgiudQlstNtzLKIY4zMTIsSDCD+TvwV8OfHH/BHT9uC5+GXgD4TePvG3wn1vTYvGvw4+OHxE+Js3hT\
wf4q0Txf8RPDvg/xX4P8Uahoekw+EfA3gSK4+KPgzRNW/wCEjmsHtPid4d8MfEQPZ6R42s/Bt3/XJ4W\
8U6D400Gx8S+Gr7+0NI1D7Ukcj2t5p95a3mn3lxpmraRq+k6nbw3eg+ILDV7O+sdR06+gt7/Tr/T7mx\
vra3u7eaFP6Y4dzt5rgYzqUPqWYYKToYrCvX6tXp+7UpK6XNSduajViuStQlCpBuEkf4j+MPh5W8PuL\
alHC5w+K+EeJqUM1yHPUrQzrKcZ+9w2MmuepKhjY3dDM8DWksVl2Y0sTgsXCFejKJqR/aHjV4rkFWGS\
Lm3V5Ubo0bfZ5Y1UqwIKlSQwYFuw/OP/AIKVfsOWX7YnwE8d6b4a8P8Ahq4+NyeD28P+EfEM9l4asNY\
vtCTX9N8R3nha31/xToWqwaZqYutPkutCu2Szex1WQ28mqWWhax4lt9S/R2QfZpGnUM0czRrcjd8sW1\
di3IDNhVChRJgfdUPxsbdbr2cRSpYijVoV6MK+FxMZQnCcIuM4SjyzhJW1TTaa6p+Z+b5XmWY5LmWX5\
zlGOq5Zm2UV6OJwuJoVJUq2HxGHqRq0K9GpFqdOrSqQhUpzi1KE4qSd1c/j/wD+CdviP4B23xH+Jf8A\
wT0/bW+NXjjWvGfjnxj8QPDHhT4eeGPHP7XH7InwYfXPE/iTxDH4z+Fmk/Cbwd8RvDHgrTvhf43/AOE\
gSbwno/8Awimg3yeK7X4h+BNd062mtPBUfiT9aLv/AIIZfsG2Wu3mr+Afh7eeAtP1HSdJ0298Lav4D/\
Zr/aT0L7ZpF5rl0Nf0e4/bV+C3xO1Pwhq11BrUdvfpomo6bYX0Ohac1zZSXFos7eU/8FYP2LfiDFoup\
/tJfsl3+ifCbxbp+m/EHxH8YPEOlaG01+Lua38KeKrbxnb2XhjwrcapPfT698PNFuI9RNxNa+CvGth4\
c+Kem2Wi61pOv+Mbf6m/4Jmf8FBvh9+194H1T4Z6p8XdE+IH7SPwaiuNP+JZTwcvwz1TxnodrqQsNM+\
IFt4JTV72zi1u1F3peh+O4NCvLvQ9E8d6fqlto01x4T1DwhrGuflmA4e4fybN8PkOa5Rhpwk5SyjHuL\
p4nlak6uAli3iPrc8RTj7SceRxp1MI+WVnTcT+7uLPGjxb8R/DzNfFfgLjzN6GKw6oUPEXhRVp4zJJV\
qdXDxwHF1Lh+GWR4ewuTYuv9TwtVYqNTF4PP4OvTco4uGIj8jal/wAEPP2Xfgymu/Frwj+0D8Z/ho/h\
C+8RfEjd478S6Z8P/wBnr4eTDUdQ8U+JPFM3hT9lVfg7efD7Q9N+0arqulv4U8ZeErPQdRs7O9K3GlW\
tzpVx/KZ4vurL4/eK/wBo/wCN2sfHXRvh34Q8U2PjLTreLxr4++Jfjz49/ELTvh98NLbSvAthpukfFv\
46/EDx1o1nr/im3+DegalDJ4+1ZNNf4j32qaAuv+Dfh74zn8K/3ff8FQ4PGtz+wD+1BbeB9R1bR5rj4\
diDx1q2gaJ4Q8S67pfwPl8QaJH+0VqOi+HPHOv6Vp2v6tB8A2+JMttZPqmm3d1NEkGmX9nqclncR/xq\
eCf2D4fib+xR+1z+0p8NfA/xyt/h5onxt8CaJ+yLF4t8L/DrXvH/AO0JbeJ/jr4Z+DfgvRbYeH/Bsuu\
2Gs+H9D8c+KrHxJa+GdQl8O+OPF/jHQoLRILz4bXNrqX5j4uZdVwea5bk3DGWVqNPCYHGZnX9niMSva\
qlRrwleUavPGnRowqwrJToup9ao0ozqVJxpy/uj9njxjlvE3AXG3iT438ZYDHY3PuJ+HuB8seMyrJqn\
1CePzDKcTScKNXAfV6mLzHMsRgK+XVKmGzKGDWQ5hj6+GweEwtfH0/n/wAAfsy/tF+Pv2XoPHOr+Ofg\
r/wzH+0L8V/EXgv4meKvFXw9+GvxV+JWi6r+zz8MrL4r2Vr8V/GPwh+BPir42eCvCD+A/hbrc9s2nX6\
3lnY+HtU8R6//AGNoviKDxHr3094f+Gvx48S/tBX3wMm/aB8L/GbRbu78C/C74L2/7F/xU1z4+aRoP7\
R3h34e+APFHws/aJ+CPws0H9uj4Lat4Q8Q+A/hJpX/AAj8vxV1Rb7wf4YsvhufB9/A2lWN2LX4y+L/A\
Ozp8Vvg1+0j8UNM+BHhP43al4X+FP7ZPjX9nX4M/FHQtC8SXmuX3xX8C+PNTg+HXhTRvG3g7Q7W3uvj\
fLp+laPqNtY6UttqTzOl3Y2MKGILpfCfx7+1R4ND/Fz4P/8ADQOo/Gu78V6l+194l+I9j4Z+I2vC08B\
fCn/hOvA+ofG7VNbXxZeaR8S/CF/4t+IXxo0bxrqXinwrd2Wm/wDCPyaUniOa28TeMtEf8rwvF+Z4bE\
0MFmazGo8LVj9am6qxMq1KipQxCo88KfNGriKs6tOnq6dStKpPEzhKVv7zzz6OvAWe5LmHFHA9ThDB0\
8+wFZ5Hh4Ze8mw+X43MZYfEZNVzL6ti8S6FfL8py/D5fjMU3GOLwmXUcLhcooYijRjP6o/ac+FP/BV6\
48QGx+JPwS13R/iJ4N+NWqeIvgh4A+D/AIw8TeMPFfwf+Mfxr8EaB8W77x78D9L0j4z+N/H+sWHiGX9\
n74reLrzxNPqnifw3F490HxPdWUun6vofi7Q9Qq/s3/tr6F8L28PfFzwB4Fufhv8At56FdfCTw1o/xk\
+Dtr4A+Ev7EHxstfi/4jk07Vvgh+2r8PNT/wCEd8HfCG5tvBPwW8fXGm3PhFfCFp4gn0q68fXNto914\
ek12z+hP2gv29Pjb8Xfi9dftPap8VNP/Z3TwD8PdI+GHg7W/DV1Y/sp/tBfGf4PfELwBJ8U/Gfw1/4U\
1o118b/HVlqvi7TPG/hTUfhl8Qta1k/CXwpc+FofEllLZ+Ltehktfjf4wftCfBZv27/Cf7Qv/BOn4X/\
HbU9d1ae08Q+Ffhz8fvEfi/xv4nv/ANrLxFL4m0TSvGOjW3h74keJdU+Jt/L4g1fwzrVlD4nv/Etzee\
JdX1eCSwn0u6t9Or6TFZ5k8czxMv7dmoYjFxpRxWJwuE/tOinzRw+YYVYShBVamGqQlTnNONV0Xh1hq\
yw7rYdfi+Q+FfiDiOCMiwz8KqE6+U8PVcdUyXJ894h/1Hx84xw+IzjhDPpcQZtjHgcJnWHxNHGUcNKn\
iMAswjnMs7yypnFPL85f9jH7RvwF8Jf8FK/2M/Bvj7VPAVtZfFuP4U+Ktb8M/DjV9WGvW3gv4q+IPCn\
9j/ET4GeNrXUbvRbSfxboPxJ0FNIujrEFi2ieK/h7Euu6ZJp9vr3hnUivzW/Y4/4KH+H/AIPfsi/Cz9\
n/AE3xh+zV4E+IXi/wdrdx4N+IN/8AtM/s46T4X0L4nfF3Wtb+KXxB+I3ir4ZeFPBlhpH7OHww8N654\
y8RXum+Dtato9aQLongvSvD+tTx6zf6SV/SLpcGcQ4DJ8ZxLLLMyzNYWjzyq1MNNwnKEZVIKV1G3tG3\
7iULu8Ukz/BvibgXxj4M4448yrw1yPjbh7hWjnGY0sGsvocSZcq2DoYyvSwU61OlKNSU1h1BL6zOrWh\
dxnOUuZv+mP8Asq1/566l/wCDnWP/AJOr5Y/a0/ZY0j9qX4Lav8INV8feJvAOuJq3hrxr8Iviv4fsNF\
ufGfwc+LXgTU7fXPBPj7wlqktlDd6Zq9tqFs0E0unahpeqXOkavqumWmr6a94LuP65rjPiH4t0/wACe\
CvEfi3U1MttounPcR26tLE13qEskdrpNik8NpO1o8+qz2UKzmJ0gM4mkAjRiPvsXSpZjg8Xl2YQ+tYH\
HU5UqsJa3hNOL5ZfFCVnpKDjNbxknZr8P4a4izrg7iHJOK+GsfLKuIOHcVQxmDxEIwm6OIw9SNWlN06\
kZ0qsVKK56VanUo1Y81OrTnTlKL/mM1f9o/xV4x8XeMrzxL4R8b6j+1R+yV/wj3wR/br8G+BtHH2f9o\
+bQtSOg2X7QXw60KMeFNF8aeJh4R8N674k8DJdaPpOsnSvEWt+Bxbf2VrPhLxJB+vv7EPhmHxK998Yd\
Hl0LxB4dbS7fTfCGqw3dhf6bqj67aWWrza/oWsWTXJSNdBmsEiniiMV7a+KX8m62Ryxyfjv+2j8Lvi5\
qWteBP2vfgxZ+J/Ef7QngbWr271L4ceDNFtbPXf2kPhNrvjHSpvHHw91CZfDMx1m1a8/4Sq58PW2nxa\
1Na6rYavDpPh4+IrvRL60/R/9j343+C/h58PPhJ8cvAeta8f2DP2lPD1zr2o6v4qXV72X9nn9q3X/AB\
7qlh8S08SS63Ms3w++D3iH4jnxXDeXKT6z4csfGUslxYXeieHtVtrnUPzvA5nLhbMqmV5o/aUJWqyrc\
sYQnSlPleZzUbctqk6eHzaXOo06/sMwdOlDG1pL9w4/4Uy/jfh/C+LXAuXwy7IM3xLwWLyynKdX+ws8\
9jOv/YEJOMb4LHYbD4nNOFb0+aeBhj8iVfGYrh+pWq/Rv7QOi+L/ANnH4j3n7anwy8L/AAxtPBs+jaZ\
Yft66NcLqFj4q8c/BHwDE8nh748eHfEFhpTm9+Ivwq8MXvjm8bSDYzXXjTwpqt54fW5fV9E8EwWv0P8\
UPBPw6/ar+B2reCdWW98TfDH4r+GtG1XSfFXgjxJ4dngvtOuJNN8VeDvGXhHxFpusT2mpW63dvo+o2U\
2LvTr2OONbiG8sZ5YZvfq+H/CfwJ+Ov7Of/AAkuh/syap+zzc/AZfFus+LPh7+y/wCLPAHjD4Xf8IV/\
wm32bVfG/hrw1+0N4M8U+IIPC/hJ/iZqfjbxfZ2cvwv1v7N/wkkng/TpNI0KLSLnQvrrVsoxtXEYXA/\
WcsxsnUq0qd3LDV371SvTpOpFzo11zTr0qPPWeJtVp0K08TiJw+Lhjsq4/wCHMBlmeZ1QyXjvhenSwm\
AxuNdSFDOcrivY4XKsXjYUqscPmGVydHD5XjczlQy6OSc2BxmaZbhcjynDYj+WX4nfDiT9jn43fGb9n\
X4yfBz4TWf7L37TvjT4lWnxx1jx3Y6lcf8ACK+EtN0iW6+Gnx98Eaf4g+JmuX0/hXw1o3ijx5deH/Dt\
u9/efEG48Z+M/hVqGreKfEU2k2HhT79/4Jef8FoPg54H8ID9lT9uf9rdfF/j3wt48t/Bv7NH7Tnj34d\
fFDwzpv7SfwTupIdC8P33jr4jeJfCdlDrXxV8Ka5Yala+MPE2q6d4cs5PD+t+EfEXiCVPEWpeKl0/9Q\
fj38Cfjt+0m3hS4+M/7HX7J3jNvAy67/wj0a/t7ftI6AbWHxF/ZDa1Ht8JfsUaeb2WU6DpZjNwZfKNu\
REEE02/8dP23f8Agk7bftB+AbHXfgV+wr8c/AXx88K+M7Lx/wCE/F2o/Dj/AIJB+BNB8Rap/aMV7rmm\
/EG9+AHxc8Kax4j03UGj8vUY7q8nkvtPudV0VJ9KOuXOr2fzOErVuFq3EVXhpTXD/EkacsRl9XJcbV+\
rYqlJzo4vBVqeHjWpRo1a2Mr1MHTi3iqeMxtBVI1alCphv6AzDNcm8T8l4Hy7xnynDZlxhwn9WwNbib\
KvEPg6hjc1yei50adLNMNmGKxlKvmeCwSwOX4TNPrME8tyrA4PFYWpOn9dh+r/AO0nr/8AwSF/axGla\
z8Tv2nf2Srb4l+EzY3Hw7+O/wAPv2n/AIT+BPjp8MdZ0H+3brwjrHgv4n+HPGkWoQHRdf8AEeoazp2m\
Xz3+hLrCw6hdaTdTQxkfmV/wWw/YJ+KHizS/h18Z/Av7TXxM+J/x3+DnhXxl4o0ew8X+BvgnpvxH1zS\
fDOpaD4n8K+HPCvir9m74NeENatrtNWtfF1xodrfWuuJcaxPJaaRLoDX+sX9x8l/sdfCT9kf42fCb4k\
fD7QfHv7XXwD/aa0rwR4D+DH/BQT9nPwX+zD+3x4pm+FXxm8Oy+PtK8WWOoeEv2UfEml+CfFXwf8XWm\
peMm8JN420rxdqFz4U1Jj9u03WRqunaX+fPxB/YS+CXh7xP4n+IXw4/a28NfB3xLZrbD4TeF/2xv2Z9\
V+DnhTxG2/TtD1ySNv2qk1Ow8RPa6Bd6vqc32Dw34rGkarfaRbTCwN9Y61B4/EOQ/XquY4DOMPkmK+v\
xpVKtXDZhjMuqTaftsFivZTwzlilOjKlisJUxSw7jGajyunPmP0Lw64/xHhxV4Sz3w/z/AMTstXCFbF\
0sqo5twVkfFuU1MBjaFKhm2EweNnmuFqZJgsZNYjBZjSyejmEcbh5UsYp0sVSjQfoXwV/4J4fD39pH4\
A2v7TXwr8YfDvQPgv4I8DT+IP2tvB/wfsvjT4U1Cw8MeHF0Hxv418GeLfFnxQ+K3jx7ibw94p8PWGqG\
P/hFZbyTw3Y3fjHQ/CnxB1fSPCXg/Xv7jv2TvjN8G/2gf2cfhF8Wf2fdO/sT4OeJfCVtZeBfDQ8MweD\
R4O03wldXXgy78Df8IxYoLTRv7D1bw9qGkeTpzz6V/wASXdpN1d6a1rdTfwGfB7UPD/7Ivx28GaJe/t\
ueKvC/hT4yeP8AQ779qK9/YN+O2i+BNG0LwFq+kaLdeFfiP4U1v4SaTdDxhpGjap458f303hhPh5b2/\
h9NFm8KabenUtWa7079rvjl4D/aL/4JhaPY/HH4T/8ABQiHwD+x9+0JcfB6y0i++DXwPj/aC8K2es6V\
8MLrwt4Osfhj4R/aU/aB8dXb2938M/CXgbUNN1KDximjaj4W8H65ZzajpUnhL4Y+D/GfxXDuerhXM81\
r0uHKawuX0qFHNfquKwsmpOHtMJmGHliMVSoU8FV5qkMRTjUjGGJlOUqjnRlGf9DeM3hTPx+4I8P8px\
/jRi6mf8XZhmuZ8BPPciz+lGdKNeOEz/g7OKeUZFj81xXE2XujhMTk2LqYOtXxWTUMPRo4RYfMqFbC/\
wBDP7bv7IngT9uH9nLxx+z745vf+Ef/AOEg/s7WfB3jm20LR/EGsfDzx34fulvvD3izRrTWIv8Ar707\
U47W40+8v9C8QatpUGp6f/aDXUf4n/8ABNT9rLXf2c/2gvi3+wl8UvBGk/D22+GnxD+LN14+1XxD4zv\
LjVk0LSpdNbwD8abQ618PvD9x4z0m88HjRYtd1bTdH0fQZfCdjo/xDXw94J0bTfFV7rnKfs3ftgf8Fg\
/FngbVfEPgnx18BPj87eK77RdV174+/Af9pJbDQ003SNCvrDSPBehfsNfso3thYXbHWb6bVbvxB4u1S\
8vEm0uGx8OeG4bCfU/Fn54/t26h/wAFMP2p/iH8FPiB8ZP2afgN8L/iX8OtK8Yaf4Z1SKzt/wBmS+8e\
eELufRDq+j674z/bA+KWi2PjPR9Gv9TP2HStM1f+0NOb4jare21mVurq9tfu84zPMsFmWC4iy7hbM6e\
Nn7LD4/DKhRrPE4ONR29/DYqvSjiME69Svh5RlJVYurh5SSmp0v5O8OeB+C+KOC+JvBvjPx54IxvDOG\
+v5twnnUs0zPLY5JxHWwtH2lsPnWR5XjquT8Sxy3BZVm1GtSpTy+rSwOc0qEqmEqYbMP7nKqQj7O62u\
G8kqWt5GbcBgktbEsxJZV5T1jUjrGWP5kf8E+f2l/EHxGufiR+z9deEfDtrpvwC0/wVY/D7xD4Y8X2n\
jbw9qHw71DSjZ6NoeoeKfAaa/wCHtK1DTlsII9NsX8V61q7aZONLv9S8Saz4Y8R+KNU/Sl7q7ngEc+i\
6lG7qhfybrST5UqlXBimOpKW2yKCrFVztBKjkV+rxpS1TlHldr/vIaeaXNrbX77aXP4Quu2voyzq2k6\
Vr+lanoWu6Zp+taJrWn3uk6zo2rWVtqOlatpWo20lnqGmanp95G8N/p89pNNFNDKjxyxysjqysQf5ZP\
2qv2d/jV/wTh/a++Hv7SH7LumeDfh5+z+PFHgu4+IWsX2pXVzq/xK8CHxZFaeLvhR478Y3/AIe8R+II\
4rTRfGevpH4e8L+HNcv9Z8NeCvDvjGDTPEXjX4aPqFn/AFIW+sL88F5Z6pb3UG0SK2m3F0JUbcIrlJt\
MSeErIEY7RIWRgVYDAz5N8dfhJ8Jv2ivh3rHwr+K+mtc6DrC/bNPvZoZdF1vw3rlnHJDp/ijwlq+p2W\
3TvEVob2QI4WWKaC6ns723u9Oury0n8rOsgWc4OWCrwqUpwlCrRr0r+0oVqb5qVejUSdpR7p2nTlOnO\
9Oc4v77w28RM38M+J6XEWV0KGZ4bEUK+BzHLcbD2uX5tlmLh7PGZbmGHb5a+Grx5Zx5k54fFUsNjcO6\
eLwuHq05P2bf2hPhx+1X8D/h5+0D8JrnVrnwF8SNJudS0hNf0qXRdd0280rVtR8O+ItA1rTnkkSLVtN\
8TaPrGn3L2s91YTTaY8+nXt9YyW95P+NX7X+hftAfsL/Bi0+DfgObSfHf7LGqfHD9ljVv2Yvix8Yte1\
G60T9h3xh4J/ah+DvjbR/hP+1D4rn1AalrH7HEdv4dnTw14wFxNrXhiC3TwRrMl3DceGdUHxB8Ef2hP\
iD/AMEgf2tL/wADfHvRdH8Ifsc/E261/wAO6p4I+E174f1jwz8MPFN/4wj8S+Hv2h/D/hlbK78X+Nvh\
6+neJpdA/tbUbu41y/0qw/4R6a61bUvhrofg7Tv65K+NeHxHFGX4zKMxrzyTi7J6UsNiKtKElFxxVLk\
nXo05te2y/HKnKVNSacKlFxU4YrCc8P6GnmWX/R/4y4b8QuEslo+JX0fPEfHUc8ybAZlWhKsquRY36x\
QyzMsVhoVP7O4t4WqYunh8bUowlTxGCzFVamGxORcQSwuJ/in8Z/C7Tf2Avippv7L2o/tS/FvWP2Sv2\
3X/AGbbn4EfHPw5ceF9B8K/Cr4b+Bf2zvgv8avCHjnw/wDtI6lq/wDZ/h7xT4Y8O+MP2ltYvJ/DFjH4\
ehn+Ivg/x1d2kj+Lbix8Idmmj6j8bvhn+3z480vxj+zz40+JngDwl+2FqXjfSYfD3in4N6d+0H8EfDn\
w91b4Xt/wU5/ZO8U+DZdcg8M/Frxh8TPhh4k0D4qaX4IvIvhr8TtKt7fwx44g0md7TU9a/aL9rj/gjd\
+z/wDHv4ceLPBfwa17Vv2WYvFOq2PiTVfCPw+0LTPEnwCv/FVjJ4AsU8bxfs8atcW+j+CfiPD4R8Cya\
VbeIPA1z4N1q5tvFWrWuu3+t6Zqmpabefk78PvFX7XPxm8HfEL/AIJjaL4X+Hnif9p39gz4daj4Z0Tx\
H441XxZ8Cbz4/fsyXfgjw38Mvix+zhceFNN+F95B49+B+v6drfhzTNF1658efCjVPElhJ8K/iSF0nxB\
4e1HULL8azjhfG8O5nLL8bgHRyTGU508qp4edbGQliEq1b+z6XNU9tCcPaYjE4d18I6dVVKuB55Qcql\
T/AEp8PPHfhfxi4Go8Z8LcU08w8TOHsZhMVx9jM4w2XcPYmhlTnleXS4tzB0cF/Z2Iw+K+o5Pk2aRyv\
iCnjcG8JgOKVh6WJpQweB/PX9ov9pX9n79srQvjj4i1r9nD44TeAvg1pPjzxh4R/aa+Dnw70z4d67qP\
xp+L1n4N0f4X6x+2j8NvDXjXU/hf4X1bxT8QNL8Xr4+8d6DZ2Hif4gzeF/B1voOn+FrHQpfD0uT8Lfi\
F/wAE9vjR+1v8P9f/AGvvFv2H4J2Pwl1b4y/tC+M9U8GePdR8U/tN/tn/ABy0TRfFHxf0681T4G+CNB\
8QfC/wloHj/wAY3FloWmWCXXhS1tvgFPc6cGufHms6nf8AuHiv4P8A/BS79gjwje+Cdc1XSfhB+zt+3\
lqyfBT47Wnxrt/2avA/7P3g344ftFeCfiB4O8V3vhzQ/gb8W/FT/DX4eaD4Znu9Wh8VaNY+ELSa18Ca\
daa14U/srRtN0W5/rM/YR/Yq+HH7BP7P2jfAz4eanq3iWeXVrrxn8QfG2tNLBeeO/iPrGmaNpWu+Jod\
DF7Pb+FNJOn6Botlp+l2ryJaWGj2wu7rUtTa/1a/8fhbg3iDi3PajzGhDL6+AdGvmcMzyyPLUqwqzqY\
Cj9Wp4ylPF0KtFR56tWcKn7irSqVasKsoVv0Tx3+kn4QfR48KsJDg3OMVxjlnFccxyngbEcEcc1XWwe\
X4jAYXC8V5k86xfDmOwvD+bYLMnVWFwOX4bEYJrM8DjsFgMDisBQxGXfz6fss6L+xH+zl+0jr37K/xu\
8Jn4VfC/4fD/AIWP+zd+2r8aZ/F37BH7WPiHVviDafEyd/B134g0bw38NfHmpfCmHwNN8QfDk2t6zeS\
aHN4i+G13az3qReNfhr4I8MFftj+0J/wSg/Ya+Ovw4ufBdj+zh8D/AIW67a6tpXibw14w+HPwv0XwHe\
W2u6HLJLa6X4rf4X3HhvU/Fnw81CCW6sdc0WPWdNmu7C/kl0vVND1620jXtKK/TcPw7xpw9T/s7L+Ec\
iz7BRlKdKrUmqU6VOUnyYV+0oOpVjh4KNOlVqSqVHRVOM6kpQ0/iHNvGn6MPjHiqfGXG30hvFXwo4pn\
Ro4bHYLBYd43DZhi6NOMsVnsVhcy+qYOtm+JqVcXjcHg6GDwlPHyxVbD4SjTrx5vx9/ZB/4IOf8ABJ7\
9o/wpr/7RPgjwJrHhzRvE3jf4ieFvDvw00PxgPG2lfDbwp4a8TJomh+HvGWk/GbWPiC5+KdzpegaZre\
pXZvYGgHjM2mm29tpjq15S+Kn/AATI8Ufsq+P/AA9pHwV/b/8A2zfjT4W8EfD83vhL9nb9p/8AaA+Ie\
ofBDwF8QNBtL4/Byz8N+HP2dPFPgXRPBfw2sBb6JZ3vg648Gatoi+FpH06wsVt761XTfxe+Nn7cPgDw\
X/wUn8Uf8FFPhv8AsofF79ob/gnH+0Z4z8M/CzSvGf7WH7O/xGsv2Zbjxjd+MPHuj/GfxB8C4bH4Z+M\
9P8e694w8W/D/AES/8P65rMPh3x5o2t6q3gyfR7Lwhp+t6Xbfbfwe/bN/ZH+N83he3u/+E7/4Jy/Fnw\
bN8WPFmnfDDxevhf4ZaPoWieL/ABvLpXxZ8O+HpvF0GteEL/4dj4023iTR9N0LV4dN8R2Oq/BbU47Lw\
7o8Xhy+jg/vXjrO/pO5bXzbAeNnGPFFXizAvD4PNamb5hjcwrUMRPBynGh9ZxeKrY3DVJUU6OLwkY0q\
1Gmq2GxVOUaKhU/x/njcPLF418NZFgsZleHnelThio0cY4OvQu5YZ4b6sk8POrXw9R46VOtUp0aTnSl\
VrzwnpHwb+Cf7QFj8efAnwT+GP/BT34ifsa/EjxTP41+Ifhvwf8b/AIS+FP27LC91LUfEeneHPBfhvw\
78Xf2hPFM1zdL/AGtpvjBPDEqT6Z5mh2vg2DW/CWi/Eq81TWfHOD+0T+yN/wAFZ/8AgnHr934j8NftY\
/BP9sL9mf8AbG+Oz3X7Wd/+0/8ACXTfg/8As5+Efip8adTvfDLeOvjZ4J+G8l9rHwU8M2XjDVPCWu2X\
jvwT4s8PAarZR6d4gtoodB8DWGtfqJr3w2+Db/FHwX8Df25PBvhj4QeLrjWta8QaZ4317XLq7+DX7RH\
wE0u8v/Hvh+Lw18RNW8NXtj8Hfjl4P8Z2/gDQPFFtHqnhnUJLfWrq88Paxqlp4m0mO1/Qr9nfwrB4z+\
CXx8/Zg+J99o/xQ+Fnw48YfEH9lFZtC1REvNf+BzfDjwrHpPhfxhr/AIRk0wxfEbTPCXjeTw3rlzpcO\
nSW134ekjLtqNpNqFx+Ovxp484rnnvC3E3DHBec4/grMqOKwWMxvDXCeY47HrF4VV+XN8wpZTS4gxGE\
x+BxNTL8bhMxzCrTqc9aphYQxWBy/H0Pp/o9+MMcFxjx/k2fYDEx4FpYujlGeZbgM5r0sRjsvkqWPwu\
K+oynSllebZRiPYY/KsRiKUaVTMcI5UZ4vJ61SeO/FvWPjH/wcG/CWX/hjb4n+A/2VPjp4o8Yfs7/AB\
Vl+GnxE+Ddp4/0rxL8S/E2jmPTdG8FN8bPiX+338DtV0TUIPCOtxyat4z8MRXPxC8Nz6K+sxeEtXjW1\
8XantfsQ/Gb/gs/+xp8JvEfhr9pj/gnL8Vfifb+JPir46+J3iv42/E7/god4q/aXsPhlYeL5rDSvBXw\
p+FPwe+Dnwv+P3xqm+FWl2WleGNNs7OIfEHUodS1nVvFPiDVrHR7jVLzSPy68WN/wUj+Hf8AwUh0X4G\
eAb39ob4sfs3/APBHY+L/AAB4Isf2cbrWfih8aGT9rP4P/F74tfska/8AFPRIfCcSfFHws3heL4ReF/\
FFjdW1t4R8MaV8KdQ0HQNJWS+0vUfGH9BXh7/gtt4a07wtrI+Jv7DH/BRLSfG/wp8H6JrHx/Glfsuwa\
T4X+HeoSeFh4h1zW9RXxT8UYrzwv4Ee2tNWvtOvNX8gSaVa/aXlZY5XX9crfSUyvwt4UwHgv4neC3Be\
aYPiHBZZnuMh/ZnGmSZtgHjFjMXgcF/auEzPKsFmOKo5TXw+Y5Zm+EwOb5BmWTYnJ8b7TNpUcXKf9BY\
r6L3HPGmZV+IvCPFvj7IamLxGEweOwmOyenHMoU6lKFPHLK8ViZY3LZYv2lGOLyrFOnjcuzF4nByhSj\
7BGJ4n/wCC403wk8NeIdZ+Nf8AwTK/4Kbpb+BND1bxP4/+JfwV/ZN+LPiL9nLR/DWk2Fx4g1DxDpvxM\
/ab8HfB3xMmh6b4ajD65d+IfAPhq30++03Uo7WTU9HtbTXtR6bw/wD8F/f+Cc9n4pPhr4z/ABT079nO\
fWPC1v418GXvjr4l/s2fGLwp470X/hJdb8Ia1deGvHf7Gnx5+KOiaReaf4j0K4trzT9f1DRtRuJJ3n0\
q11GCx1uXTPUx/wAFzf8AglkSQP2o1JHUD4K/tEEjHByP+FScc18K/sv/APBXP9nX4WfBrxn8AvgT4e\
tfipd/BjxV4ok+Geu/Fb4/fAX9mfwR8R/hh4/+MXxB1Hwnq+reMP2gfEfhjULbxnF4fsvEEmpaTo/hT\
WZbLydDudVXRbfxTp4t/icy8YPo68TYKOUcJ+HuXZDmtWUpVcXT43qYurGivZez9hTxcXhaMlVTVeri\
KeJhUoVXSpQw1ZRxK+N4m+jx9I/gPLJZ9xh4KcdZZlEZqlGdXgfiL36zhUqeyhCjls61arKnTqShSox\
dR8kmlJJxPJP2hP2nf2WIv2yPhf8AtC/sO/Hbxt4f1743/D3xbov7Yv7Pvh74BfGXS3/aZ+FXiG0e08\
G+J9M8GeOPgXarefF/wV488XXfiTWLSw1a18Y6J4c1TxnqFn4bnk8Q+K7i9+9fgx4Z8P8Axw8QfDy28\
C65ZeKPCPirQtF8WXnjbwvq41rw5qfhPVLSPxCde8O6xa6I0MdlJoV/ptnaXB+22F3qMkc9vfTWN7bl\
fzA8b/En/gnD+2lrnjDwtrPwE+BngHXvif8AETw1c/FPQPBum/D+9Hi79oSw1Txfqo8Y+Jf2g/2fr2T\
TfFXjzUfHumfFK28OeIb/AFbSPEHi/SbJr62057DXI/7Q+m/2ZNO/aH/4Jn+NvAHhbwx8HNA8a/sWfF\
WOTSPhDpenbI/it4Otm1v4h+Pdc+HnhrVdWg02G58a39/4gLeFtBup74+MNA8BeFdI0We58V3Gv6pX5\
3n2MyPKI4GGBrYl5C5rDYOdVYR0KPtMRia1Waq4Smoyp4zH4mpy89SqsLX/AHX1mvHE06eD+Co4mvnV\
SthKuGrx4jy2EPrWHrUa9DG06f1anWpQxuDxfssbhcRRwjpVIU6uGhKpg5RqzhSjRU8R+vH7f37FXhb\
9uD4H3fw51OTSdM8XaHdT654E17VtOgubNNSezltrzw1rd/DZSahpvhXUsWLXMumyJc2t/oulaqIb59\
Ljsbj+c/8A4Jw/C34Ca1rnx3/YF/ah+Avwml8J6h4Sm8M/Dj9pfxv8G/hD4J/ak+HXxH+KLW/grXfhr\
c6rfeH9Z1CW90v4m+INY0zwr4y1o2j6P4ni8K+HL+K31Px/8PvB1n/XH4A8f+DPin4M8PfEL4e+IdP8\
VeDfFWnpqeha7pjyNbXlsZJIJo5IZ40msNQgu4bi3u7S4jiurK6tJrS7hhuYZYk/Ez/gsj+wF4f+MXh\
oftS6Jomn69rPw0TwxqfxM+HtzpOvjSvH3h3wzqZhh8TapcfDy703Wbt7PRNRnsPETtqtlKfCNkZ9P1\
rQLrQbaa6+F4t4Wo5ysNm2FwNHFZ5lcZqnGryxp4uhOMlUwOInKnVtRqNqpCXI5Ua8YVKcoXqc39IfR\
68eMy8N3nPh9nvFWZZD4W8eVsLUxlfL/b1sXw/muGr0Z4PirKMNSxeCc8ywdOnLC4qh7eNDM8rr18Ji\
6OJdPCKj+N3w4+Gtp/wTI/bOs/2ePjf8efj74i0K5/4SbWfEumfDz4o/tX/s66V8RfhtpHg2+vPhdqX\
hE/DXxdDY+JbZ9Mlhi0kw6jBaaf4/8M+OPBusX2i+H7S38beKf6ofCfwK1PxH4V8M+Jvgx+2r+1n4T+\
Fnijw/o3inwNon2/4LfFLydB8Tadba7bX3/CcftT/s+eM/H2rfbX1CS98rxF4jv5rD+0f7Oso9P0y0s\
tMs/wAstKf4kf8ABWX9j/xj8KPH9xp/7M/7b/wn1/4teHfA48Yjwh4r1rxj4Q8MX2leGtc0L4z2lj8O\
bSLQL5vEN18PJ/GNjoGl6XqfhTxl4Y+F/wAZdM8L6BYar8MtIuPP/wDgk9+3vpng3x74q/ZN+KfjnXd\
Vg0/xh8Nfhb4F0nW/hjrPw18TeCfiBqOk6not9pPin4Z2vgqOHwRrd34h0qw0nxrZjVruPS/iD9tvrK\
XxXpesa74/b5zhSeT0qmEyeVOVDD46Mp5VXvUweLnRpw5q2W4h/Wfr1TFYLlc63tOWnUpunPkTpJv9t\
+kFhvEjHYTPfEqji6Oa5zwpWoYfj7KOTBcS8PYXM8ZXjRy7jbJof2O+F8JkXFHtaeGy94L2mLwmNWLw\
zxM6ePlCP7W/8Kg/al8Lf8iD+2H/AMJj9v8A+Qt/w1F+z78OviT/AGd9l/48P+EG/wCGadT+C/8AYvn\
faLz+0/7a/wCEl+0/ZdP/ALN/sfyL/wDtU/sb9urw/wD8Tf8A4WN+yZ8Wvsn/ADT7/hS3xh/Z4/4SDz\
/9F/5LD/wvz4of8Ih9k877b/yI2uf2h/Zv9l/8Sz7b/bGn/WdFfoX9j4aOtPE4unUWsZfXcXPla2fJV\
rVKU7Oz5akJwltOEotp/wAb/wDESM6qfu8ZkvD+MwlT3atH/VrIMN7Wm9J0/rOBy7CY7D+0jePt8His\
NiqV/aYfEUa0YVI/Ik/iz9utzHMn7On7J6ywEsoT9tT4wfvUbaZYGV/2CApVwigE42sAwPHOb4b/AGl\
/j5feH9EvPE3/AAT1/ae0fxLcaTp8viPR9C+JX7EfiLRNJ19rWL+2tM0bxBqf7WWk3Ou6Vb6l9qht72\
40rTZrqGFJ5bCzeRreP7NqlN/osjXQ81opMC6jX51TaoVbsL1G1VCuF6qQ2Mpzay3GzcV/rBjLxTSXJ\
gLO7Ts/9h5r6Pls0ryldNtONLjXhuNKcH4RcOylOUHzvE8Wc8VFTTjFLihQcZ80XNyhKSdOHJKC51P8\
Wv2x/C37Of7amj3fhf8AaG/Zp/a3+DXxQ8Ca3pehRXGs/skfG/436Z4v8DXFroXiy80HUPHP7Fd94m0\
XxZ4Du4tcv4LdtI8e6V4m8Na9YX01ncaROLyPUvyH1n/gmj+wV4G8Z6Ve/wDDRunfBLxLNfv428CeEf\
2r/wBn39oD9kv4e65onhLxd4UHiLQPCnxH/bm0vxRonjS/0rTvFGl+TpuuaF4/a9EsP/CRaPq+my6nK\
f7KqK8PMeFo5rOlUzKllmb1cPpTq43KoYivGCnzJe0WJpRUkm7SpU6UVN86prWL/SuC/HmpwBh8bheC\
sfxx4e4HN06mNwHDHH2IyfLK+Klh40ZVHhJ5Lj6tShKUI81HG4rHVpYdLDTxUklVX8iEX7O3xa8U+MN\
L8KfCT/gunYaifEGq6L4e8EeDtT/4Kyax8QviBq+t6sbPS7HQrafwN8LfD8HiTU7vXLgxafa2Og20pW\
5trQR3Vyhubjk/2j/hX/wVM/Z48VaD8Z/jX8ddM+E3gvwb42svDvgnx/8ADXwkfjRqiHwsPEvj3Tbfw\
fqPxh+MHjr4m/EnxJqlvpnxUh8MWvjvxDBp8Vv8bfEvgK81DwX4D8ceLrGX+u7xz4B8CfFDwtqngb4l\
+CvCXxD8E659i/trwd458OaP4t8Lax/Zmo2msab/AGp4e1+zuLTUPs+rafYXUHmwv5VzZQzx7ZYkZfl\
/xH/wTm/YA8WaDrHhnXf2Jf2UrnR9d0+60zUIrX4A/C7Srz7NdxNFJJY6tpPheC70nUE3B7e7tJ4Lq1\
mjSe2minjjkXycTwNQrU6+HeDouOJ5Ze3w+MzHL6tOabacY06uJ54wly1YwdWnSlOMVOn7kZn6HkP0r\
M2yzG5XnK4kzP2mUqpSllWc8PcH8X4DH4eUaMZxrYjHYDJ/q1XE0o1cHVxKy7F46hh6taeHxt8ViKL/\
ABX+CFv/AMFPv28v2dNbtLr4o/sn/tHfD7W28efCj42+B/2sPDnjvwd4C8ZjUrjwV8Rvg58SPhr4H+F\
37GPw48XfD1Z/hPrngXxT4c1mTxnrxvbT4haTr1tb+GdeslsNL8N8Bftrftzf8Ek76z/YZ/aSvfCnxn\
1DwZ4M0Hx5+ztY+FfBn/CzX+JHwxurLxEh+GNn8avFX7QPgC4+DnhXTtY8Favomk32ueCvF19pBN4bb\
SLvwzpPhrTL/wAf1L4R2f8AwSb/AGhB4c+Onxz/AGkG+CWg6b4Vh8K+CPg38dP2g/BWlfE74NSWv7QO\
r2NrfzfC6+XUvBFzB4/1fxDqGlx6r4q0+zh+JGrjQbwXXhX4k658SfAf6w/tBf8ABNb4R/8ABQ39mnT\
/AIgfs3/tffGDxZpWrzH4vfswan8TfH0fxq8DeDvGTaHoXhjXNCj+JvxM8G6r8XvBnhnU7rwgYdf0B/\
GckHh/xRA+pXPhafUdDj0QfnaybiShiIulisVX454dhBVacc1VSrj8t5ledJYmnFyw1dwvRqVqlWVLH\
x/2jC2qVoS/srE+JXgtmWV1YY7I8hy36K3jDicTUy7HVeAZYXAcLcZ+xvCjmE8nxdWFPO8sjiXHMcFg\
MFgaWP4TrSjlOfupgcurUeN+Ff8AwW++LHxQ8W3/AIS/4YgsPCk8Fnq9zpFy3xt+MXxb1DxfPpWp29q\
un+EvAH7M37FnjvxZqt3Po732sBn8PwwWelaNd3GpzWMsXkEr84/2Lfj78edO8QeIfgF+1L8YrvXItA\
+Jf7UMXxB8A/tXfskeGf2yvhV4O+MXwhHg7xD8TvGXw88RfCnxt4Y1/W7vSV13xs/ieSyv9esfDo+I9\
nrGqrfQ+LD4isiv0PK8dm2a4KjmGWZjmuKwWJvKE6tHI1PV3lTcIvDypuk70pU6tJVoThNTcnZv+NOO\
uFvD7gDibH8I8ccHcA5FxLknLRxGHy/MvFKWHagkqeKjiKsM3oYyOYUlHMKOMy/HVMuxGGxVCeFhSXN\
Tj3Pxy/Zt+Jv/AARw+GXxw+E+ifs9z/tXf8Ed/wBpCT4tfErx/on7Pvw/8ba/8fP2TPiHpviTxH8UPC\
3i3x8vjT4wavN4x+F8HwX8H/DPwde+Nota8OabpNv8GtM8WTWnhzxhBey/Fr8f/g14Z/4J1/tj6/8AF\
/8AYt1r/goV4G+FPwY8C6FDJ8Hf2jP2h7zw7oWlah8Or5NFm13wh8L4f2n7jwv4q0X4tXvji206/wDE\
d9o2qWdh4ssPD95ceKfDltanTdPv/wDRghT+ybpbaKDbpV7KWidZfk0++lJJt/KcgQ2MzBfKCZC3ErJ\
gCWML+cH7Vv8AwR9/4J8/tY6L4huPFf7LPwC8MfFXVvGOq/E+0+NHhj4N+AtN8dT/ABS1W18RRXvizx\
9faXpNpL8WLK9ufFOtXGq6br893BfXl1Hq0clp4hsNI1rTf7k4i8b+GOOKmE8QeOsq4iwXjtkk6OIXE\
vDWa4DD0uJ3RrRlL/WTJszweIwkc4WEgsNhM7yzF4CVKvCjisbgsa54143+Cnwfk+YVoYPHYbDvAVbU\
oYiSxdDHZZGTfNPBZhl1fD46OH9+bxGCc6lDE05OMoe0hh50PxZ/4JIf8E4vgz8e9b/bUsf2jPiR4T/\
bl+Fvwd+M2sfB34P/ABi+FHjLQbj4EfEfSvid8P8Awl8YfF+seGfG3w++JVx4otfGul6N8UNO0LUPDi\
yQeF/CFnqy+GdL8SfEG90681PQP1lvP2l/B3/BMH9lz44eAPi83wt068/ZS+CnjX4o/AbQLG78L/BDw\
d8dPh9pWl6tP8PPAuj6hDFc2nhz4q6v8Q7K68OyWP8AZkuo3V9q9rc2Fr4ouXvNQu/oj/gn5N8LtH+G\
PjL4beC/2afhV+yH8Q/h548msPjp8DvhL4J8C/Dvw0nxCvvD2hJb/E3TPDfgiGJb3w54i8N6ZpH9l6t\
dJM13b+Hns7TUtYsdMt9Tueh/bp/YI/Z+/wCCh3wetvgx+0FZeLU0LTPE2j+LNC8QeA/EsvhfxTo2qa\
ReQXT2ryy2l3p3ifwzeJbxJfaLrunato1xNa2Op/YE1nSNF1LTf504tzDw7458Z+C/FvhTJsVk/AeX5\
hlkMyyuEXQxeb8ORlgaPEeCr0I4rDUaGdYp4XFY7ATnXpUsszepPDwlhsDXxdN+DmfhDmGXcW8J4/Ku\
I4cLcTZNjfq2ZYzGVcfmeBxuS5lWw/16OMVKtWxGN+pYaFHH5HiYrE1MLUw8aGHg8Hj8bRr/ACx/wRT\
/AGaPiz+zZ+xbZeJv2jdU1m9/aW/bJ+Knjv8Abb/aItda0eLwxL4c+Lv7QMeh6jdeFZfByeBfDreAdd\
tvBuh+Dl1/QpLAppfiw+IbOwnbSotOhi6zxla/ti6J+0toHxU+H37Jmn6E0+oeF/D3xz8T/D79oL4f+\
K/Bvxy+GFvaQlo7rwJ490zwVfS/E/w7Fd3EPh7X7htMuLdrS40m7OqeHriBY8R/+Cdv7Ufw6Up+zZ/w\
VW/az8LrreP+E1/4ai0H4d/tnm+OmkHw03gRvHun6Mfho0LX2unUjZm4OrmfTjMYTpUHm+DX/wDwTm/\
4KBaj+018PvjL4y/bq+FXx3m0vwP4o8C654m+IPwG8bfBHxT8MdLX7Tqng/WPhboX7J/xn8G3PjvVLz\
UNc8WaXqh1Xxfoltp+m+JLt/s2vymyt7H5Lxr48458Y+M8643zPhHG5NnWf5w8xqxy7EZJQwGEhVrJU\
MPg5Sp4vFUcNgcPKGDo0qOBwyWHhKhUrrDOcpf2vwz4a+FWQYTH1sq+kVwjnGE+oYiFPBZnlPHmFzSq\
qVGdSpCrQp5JTyP2ladKVTDxln+MlUl9WlRoLMJRwtP7x1T9vPwbpvxe0v8AZ91P4J/GZPjF4l0nx9d\
eE/AK6n+ztf3PirxJ8O/hk/xb1P4c2OuWXx+l0fSviHP4QuPC9xFp+rahpy2cHj/w9qmsz6Voer2uqt\
/E74H/AOCbOt/tg/DPwx/wUp1D9oX4V/H/APad+IvjD4afF39qL9kXxF8B/Bn7Lvxt0vVPib4A1zw54\
G8XaoPgv8bI/D2ni/0bwwPiV8N9X8Y+CtO0Px/pM48b6vo+vQ+INa8GeJ/6OPjr/wAE4dB+Dn/BRX4Y\
/t46j+0Z8Xfh38MdY1u+0PxH4t0nTl8X638Ltb/4Vp8Pvhz8L9M+Ifxj+KvjPxBdx+DNX8U2fjE3viX\
VdC1C1t7LXbXwHrMtv4YvrWaz9D/aY/4IjfD/AMX/ABF8eftKfsrfErXPgB+0z8R7z4Z+I/ip4h0q28\
MeF9P+MXif4Z67e+Lde14eJPB3gj/i0njz4iaibPTvHVzJ4e8cfCrVku5vFfiL4EeMvHOn6Bruk/u30\
XuP8ko5N4zeG3iXWy/g3iPP8Zl39i8R43I8qz+nRwVL2tCtlWYTqYWpmOWZXnFDGVcZVzTI8PhsS8Tl\
uGw2MhXhQnDCflXjFkHDWU4Twyzvwf45zX2uY5JRxeaTwcsXlmJyziRyx1DF08F9YjVwteeX4epTowj\
iJ4+hVo4ypUu6WKdI/kKnutJ+FOdT/bA+AXw4+M9v4f1+w8I+ItQ8Karr/wCxv8afCXh3xN41+H/hL4\
ZeIPFv7Ofw107w5pviHXtUh8SeKNfn0nwbp3xA1O3stQgt9R8VWttY6LY6l9o/s9fC7/gnv+0B+0T4j\
8DfCH4G/t9at8PPFnwi0v47fDrxd+zDd+GfFPxA/Zw8VeE9Zn+HHxc/Z3vYPE95rF94g8HvefE3w5PZ\
694p0Lw94ntF8IReHryC51GPxVJL94aH8Tf+CsH7Oa+DfgN+21/wRN0H/gpH4q1zx7dfDz4U/GX4f/E\
bwfrPwN1DSPDl3onh2z8feLPC0vwo8ZaV8D5tb8Q+KNa1xvEvi6L4dWC6b4ovI4PDvh2LSvEu79jP+C\
O37F/xW/Yv+B/7Q0HxR+G/wm+CGp/tH/tjfFz9rbw1+z58GdftvFXhj4BeAPjF4R+F8WifAO+1bRvBW\
haPceJPCM/hbU9Gz4dtrjw60Ol2z6TeS2k4SH6rxR+ivwDwhwJn3FPEmE4Lq5lm+Mj/AGRUyPiDhXiH\
CZ9hK1aNKvPLcLllSpneVLLa1Ks62JzCnhlUp1Fl06NGvhqzxHj8JfSW+lnl+NyPBr6RfFv9n8PSf7q\
GacSYXDV6E6NejPB5lleIzWtk+LpVKVWEnTqUcVhZ14/W6ODws6eH9l+fX7F//BNr4zSeA/iZ+z/8U/\
8AgoH/AMFAP2eP2kPA954k8QeAPhn4W/aHWL4daR8LvFlrbXXgb4g6b4S8K6ZZ2nxB8Op481DXYvEA0\
HxBAU1GGXTr2+0u+u4Lh/0cP7IP/BU4biv/AAWFVvlO1T/wT7/Z3XLY4DOPExwufRTjPQ9/qb9qD4Ia\
14yj8M/H34G6R4e/4am+C4fUfhZrGrvZ2mm+L9BuvtVl4u+FXjGS7g2ajoGqeGdX8Twaf5k+nz6Zq2q\
LPaazokVzqdzL7H8C/jFoXxz+HGjeOdJh/sjV/m0Tx74KupLz+3fhn8R9Jigi8Z/DfxTaappdjd2PiD\
SNXkkt5Bc2No9zD5F/DD9ku7aST+Kcq4YyvCZjichzH65hsbCLq4avh8xzLBrG4SMrL2ywmIw1OeMwk\
pezxEeV+5OjiItfWJ06X7xjPpF+KVbJcvx0cVkHFOAwzVOrT4g4M4K4kr4DFzhFVHh6+f5DmmJo4XHR\
pRqQcKlNTqUp0akZPDUqk/44vjL+xf8A8FHP+CZH7Sug/te+GNJ/Zs+P2ty698XdZ8MfEHwJ8PfiFov\
iqLTtHW28Q6zceMfhF4H8L6L4O0C+vPgPZ/EDRW0yzu7pdN8G3Gvf2LcprPhLQvE8G3+1Sf8Ago18XL\
a//bk8T/Bz4EeOfAnw78JeAPHnjab9lO98Daz4R8EePvDep6Jda/qvxp8A/Fiy8UeIPiUb/wCAN74UG\
uX/AIbFz4D8WeBtN+FXjxPEXinwX4O0C4k/sh+Kvwz8K/GT4ceNPhb42tPtfhjxz4f1DQNT2QadcXlj\
9riP2LW9I/tawure18QafqCWl9p1zJbzfZL/AE62ukQvCtfzR/AKH4j/APBKT9sXVPgL4P8Ag34cm/Z\
/8Q3vwi8N+KfiJDa67pN74/0bxTf+KtX03TfC+neGvg/I3ij4m2ut+Jfilr/w30KK9nvNQsvCnjz4G2\
eoeO9fs/gnDoHlcS8Dxy5wx2XZ5mOWZdVqxq4mVGt7WdHFpOFHMp050qksVK/sqWMc6irTowhUVR1Iy\
m/6R8EPpU4ji+OM4X4v8K+DeNuMsHgKuAyXD5jlzy/DZnw9Vq06+Z8EYbF4XH4ShkdBwWOx/DtKjhKm\
XYfMsViMJLCwwlajQjrfsU/8Fqf2n5NM8J/Bv41f8E+v2mPilr/gCHxZoHxF8c/CvXG+LnxthPhHWvE\
Ph1Rr/wAD4/h7pOoW+o6X4kstE0DVrzXdYsLllli1XUJ5tcu5tHP6On/grj4S0oLqXjz9hH/gpx8LfB\
NkwuvF3xL+IP7Imo6Z4F+H3hm2zPr/AI38Z32leMr28s/Cmk6TFeahqMtrZXlzHZ6fM8FrcSKsT/lT+\
2n8Kde/Yd+K3hj9rP8AZu+KfiLX/h18XtL1TxP8HtX8B/DPw1468J+Dfh94fttC+Ji+DfCXir4dfCu5\
tdH0Xw58NbXxFf8AhjUL3UZLHXvgP4V17wHLcaZ4e+FmkaT8S/6P/wBmv9ozwJ+098OD8QvAdz5sGm+\
INU8HeJbVIdZFnp/irRIrK4votIvtd0PTbjWvD9xp+p6Vf6deS2FjczWGsW39oafpeprfaVZe7kb4jz\
FYvDvi2dPM8ulCOIo1sJgKyjKcFKnVg8MqD+q4mKdalGb9soynF1ZJQmflXirT8FeDKnDub0vo80cbw\
LxpRxVbJ8yy7iHirLKlWlQxUqeMwOLhnU82gs9ySrUWW5hVw8f7OqVaNDERwFKVWtRfwx/w/M/4JZkk\
D9qIEjGR/wAKU/aJyM9Mj/hUnFfT2gf8FE/2CfEuhaL4i079sz9mK20/X9J03WrG31/43fDvwprsFnq\
tnDfWsOteFvFPiCz1Pw1qywTotzp+o2drf2cyvb3ltBcRyRL9kMqspVgGVgVZWAKspGCCD1BFfMWvfs\
R/sYeKtd1jxR4n/ZF/Zg8R+JfEWq6jr3iDxFr3wC+FOsa7ruuaxdzahq+s6xq2oeE5LjU9Vur+4uJ7m\
4nkeaead5JXZ2Zj73sON6Wv9p5Vj7/Z+o4vCcvnzf2jjee+3LyQtvzPY/Jf7U+i1j/c/wBR+P8AhT2e\
vtP9auHeIPa3duT2P+pvDP1flXve19viud+57GHxnqHww+L3wn+L+jXPiH4P/FD4ffFrwrbazd6DN4j\
+GnjPw3470DTdds7Gw1S78N3mseFNQura01SLTtU065+zSSiZLfUIWZFjeFpPTq/Nj4l/8Ef/APgmx8\
V9bg8Q+J/2TvAGk6hbaTFo0UPw01Lxn8GtENpDd399HPP4X+EPifQ9LvNW8/UbgNfT2cl7JDFBbyTvb\
2ttFD5vB/wRg/Yy8Js15+zxe/tE/sgeOwq2GsfEv9mn9ov4q+F/G/iLwrcAXF14N1TUPHWueIbSXwld\
atZ6Pf3EENnFcfbvDNmVuliikjnp4vjWHvVMhy7GQp/FKlmWIp1Jr+aFCpljpwbulyzxjV9XU1sl/q7\
9GLMLfU/FjjPh3E4n4KOP4IyjF4LDS/lxGaYHjiOMrU0k262H4dVRtqKwlk5n6v6tq2laBpWp67rup6\
fouiaLp97q2s6zq17badpWk6Vp1tJeahqep6heSJDYafBaQzSzTSukcUcTO7Kqkj+QH/goF+3j4P8AD\
Hw58J/FLxN8UPiRqPx5+I/xV+O0mk+BPiUtl8YP2BvgrN8IXv8AT9I8KQ6dYfBHWvDPxP8AHGo/Dnxn\
8PdB8P6hp0o0wav8Rl8Y+JfEehWgLah3v7SfwL8IfFD4RRaB+yv+3P8A8FWf2lde8aeItR0XSbn4meP\
vjJ4/+Atl4x+HmhH4t6f4U8WeC4vgfY3HxQ8V30Xh21bT/D1rPBapHHJq3iHU9K0eyd7v8b/2i7X9pX\
xZYy+E/wBo/wCMyeJNBh/aP+J/xc+NWt+JP2cfhj8OtW+AGoeK7zwtovj3xlf+KdM1GLXtTvL0RXdje\
eCbO20Kxv8AWfAPhjTLK11nxRrOk2mnfM8Y8QcV4ThbNa2D4cxOCzL91GnUoYjBVYwjOvRhOU5yqRqU\
rwlNOrGhUjQj+/lOCg5Q/afo2+EPgDxB49cA5dxF40ZJxPwU3j62NwWZ5RxLl9fE1cLlWYYrD08Ph6O\
Cq4THOOJoYadPAVs1wlXNayWWUcNip4mnQxH1f+x/+1b+0v4d8c6D4s+KfwA+B/7Ufgi/+EHgfwffeG\
vHHxHk+IPxT+GX7PPxZ8PnStDPh74KeF/FPjvxl4a+GL6D8RdDn8R20Pwn8RzQeF9WutFgtNMHiG5W8\
8X8L/Gr4jfE3V/iX4b/AGctO/bk+F/ws/a70H4h+PPjl8OtW+LS/Gv4U6L8M/GXxl8DaR8VP2nNS+I/\
jey8IL4r+HEuj+H/AIgeDfEOr6/rngy+0p/CcMviX453+nan4l0Sy8P/AGmvEv7bfwW+DHg/WPin8Ev\
gt8XfCtlp9l4t8P8A7bHw0vfE/wARPF1/4itPCnh/wz4G+JsnxP8Ah34g0HU7nXdJ8N+OPDFn4e17xd\
4ds113UfDVpcaSviXUdJfUa4/w5+2J438FeIvgp+0Xo1r4H8SftP8AwN8Ux+NtV+Nfwn8X+ONf0vW/h\
34J8Q+IPBF58NP2jL/w3dTWXxgsv+Ea0LQIP+E38OeKvs194A8X3Gk+Ltb8R305n8M/j3G01HCZXDEc\
QZxPEUaihUoY7DUJ41rEOFOvDC43CUE5XoQqSjhlJ0MRTlOvCvH3JS/0f+jPgVmGacf08u8IPDanw/m\
+BrVcLmfCufZpheG6f9l08RictxPEHDfEGaTjRcczr4KjXzx04Ztk+MpYfLK+WVpPE0aXr37LcH/BNb\
4n6V4w0H9qPXviZ+zhrPhDxGbv9n341Wuj33jbwtq8WhH4eatr3hX4g/Db4R6YfEeoeM9KbXLO48P69\
Pq80EtrPFcajdWevadN/wAJMV97/wDBUn9uDwj+1r8INPvfi3+zJ8EPAHjzw5qOn2nw88f/AAk/ba/Z\
m/ay8XapM815cXfgPxP4a+EXimz1b4f+FX0e48T3tp4unsteg0PVoItJ/sS4tvFWppIV+V5nmlDhTFL\
J8uwmEz3C0YRccXUed5VXqqTcm6+Ep5lgVGcZuUVJ0pylCMG6s1y2/aOAfo8YvxwyjE8XeIEPE/wzzm\
liquGp5Vw3xpwXxdklPDQjTlSrYXOMRgczUsRX5nPMqNCvTofX/b4inhMGsQsNS6n9mH/gpb+1h+xp+\
2Z46/Ze/wCCjXgf46R32l+Emi+G/iD4lePksPC/xU+F6eH9T+MGueL/ABNoPiT9qv4keHPCPxgHgzwx\
4zHhPXND8c6n4e8ST/AXxT8N7S3k8etr+s6H+/Xwe/4LA/sCfGbVrnwz8OPjTrfjS60jRW8T6nrelfB\
z47SeGdC8A2tzp9nffEfx34w1H4Z2+neAvAGntqmmNrXiPXLnTtC0yO7W8v7+1tXLp+M//BwP4m/Z+/\
bU8Nfsr/BL4UeBfj14z/aS8dfFrVPAX7Mf7UPgXwv8U7b9nHwLZy/EPwUfjnJ4w1jSYf7O+N3g+PxH8\
LfhWv2HTdJ8TT3GqnRb/wAI2XivUNPvvCWsflp+wR+3vb6t8E9C/ZU/b/8A2XPgzPffsq/HPxj8E5NS\
+J9voF3L4B+JvgPwH4btfG3gDWbjx9471LTPglfeM18L6lrurWNxrfg/w9q/ivwf4yj8J3sl9Zad4Ss\
P7n4842pvFwrcO4HA5Hh8H7KjmGFjgM0xOGoYmpHnw31arRx+JrUoVsJT5q0q8KsvrDhGNL2c41of4F\
+F3C/hXneSZlU4wyTiviXiStWn7Chw1jMnwv1DB06ScsTUwGNyvFVs2lVxNSFOlgsDVwCwuDo4vF1cV\
NYf2Mv6Pv2+/wBpbUPhL8W/2Vv25f2b7Lwl8WvAt14f8d/DvXvG/g7x9rHijwF8YfD2navf+d8Ib/xD\
4Ku5PDnhu6g1VvFd3omqPeasza7pN7PqWg3EXhOCKf4Y03/g7E/Z7Gj6XqPjb9nTXfhhqmrrq8kXg3x\
b8WLfW/GukpofiTW/B+p2/jPw/wDDD4aeIn+HHiCLxL4a16BtC8RtpPiBbezt9VfSV0bVdG1HUTwz+x\
hF8cv+F13/AOx58TfiJ8EPih8QfhRYav8AGn4L/Fa88WfEPxx8ZNTvfHdlrHi34zzeD/jx8YNK0/xb8\
abCDxV490/w1qfiiy8QeA4td1yydfEPgzxfBF8R0+MP2F/2pviX+yP8X/BH7XXwt+COqaT+zR+0fH8L\
vAP7a+leKtD1DWdd17w14U1zxV4A8M/tBfDjxt4I8MPNr/i7wfruhftAaho/hmz0W/1Dxn4N0vWfCE8\
t14t8LeGprL2fBDibwwqcS5lgvE3hTF5jguIqEsRhqmQcSYTKMPVx9H2dJ11j8Xw9xBGjDFynhcFi6e\
KyuH1LGVsvqYnEUMDVzHNcHHiV4YZTU4VwviB4S8e4njjhChi8NlE8PmmV1MJnWSYvFUsXjcHlOZYGj\
i62EqyxWHw2Z4jKswy3MMRhsypZVmUJ4bLsXRw2Ar/v54s/4Lh/s3/C3TodR+N3wL/bM+Cmlm9j0I+O\
/i9+zJ8SfgV8H9d8UeRcznRfAvxI/aY0nwGviW5urfT9WvNMsrmw0vX7zS9Kub+bQbIWd/DZ2PBH/Be\
n/gmH46u9N0+6/aU8G+Ate1o6avhHRte8TeBPGGt+KbzVNd1vw0NCt9C+DPjHxVeaNrQ1bRFU6bq8Om\
ahcRavpl7YW15a3cE5+m/DH/BO3/gln428NeHvGfgz9hb9gHxd4P8AF2h6T4n8KeK/DH7Mn7Ouv+GvE\
/hrX7C31XQvEPh7XdK8ES2utaHe6Xd2tzaXdtLLb3NvcxzQyPG6see+JH/BJX9gr4q+D9a+GPif4SeN\
NL+DGvf2d9u/Z7+G/wC0f+098G/2Z4P7L1Sx8QW39jfs0fCD4y6H4C8ObvFenW+t3P8AZ3h21+2eIJJ\
9fu/P1m6ub6b92jgfo6061DB47NuOcrxFKu4Yqr/ZORYmVKCkozUMBPN8E51qK526VXHUo1ZRVNzoXd\
SP8682btOUaeGqJq6XtKsbu2nvqnKyfdRdt9djvdO/bQ/Yv/aD8J+OfCUXxI/tzwFqPh+88LfEnV9Y8\
IfFTwR4F0HRPGen6rov9neM/idrPhjTdK8CtqccepWNhLd6tYTXl6VtNNlkv3hjb8vNb/4Ll/s4fsY/\
FvxN+yh8avFnxC/aEh8L32n2nwa+P3gmb4Y39r8RfC83grR/G194c8a+N/GPxH0DRPFPjvwzpuu6Rp+\
oa7pd5MNYlljbUrLT9aFwt91+s/8ABtz/AMEvdH8TaN40+D/ww1b4JX+n6F4g8OeIbWHTPhV+1FoHiv\
S9d1Dw3qVtd6l4Q/b9+Ffxh0nQtZ0u78OkWOpaBY6NqKWviDVba4urm3uRCvzF8Yv+DbXwx4V+GXifx\
D+yp+2l+3LP8d9Kn8M+LPh9qnxP+OHhC8vtO8Q+CNTm1rRbnwD498H/AA68Na38PfFrx3WrWUVzBrlt\
p15Z+Ib/AE+/+xS3Vl4i0H878UOBvDXDcPYvi7wy8Y8wzHPcs9l9Xy7H8J1cDmeNw0q7o4yhiaOGzbO\
cphLDUpLNMHClmmLq4n2X1ONTA1sVVifpnhZn2R4TiOhlXiFwnh894XzNShKNTM8Tg6GExTUXh8Z9Zw\
tBYyNO8XhsSo0lBUqrxE6dd4ajA+8/Cf8AwcBf8Etdd0a2vfE/x+1D4Z+IG87+0fBXiz4d+OfEes6Nt\
urmKz+0+I/hFonifwzq32iyht7tP7K1/UPIiv44L77JqEdzZW/1H8D/APgqZ/wT5/aK12y8LfCv9qf4\
a33ibWL3w9pvhjw74zk134T67451HxTq2raBoen/AA50j4s6Nodx8SL2XXdE1GyeLQY9Rkt7tIra5WG\
a5tkm/lX/AGD/APgkx8Vv2yvAuqeK/Bv/AAVD8EfDvx/8MfiHf3XxG/Zn1T9jrw9+0hZfAzW9a8Qa14\
r8A6Ymu/tIfHvX9c+Jnws1HwvPBceG77xRPrf2zSkuPD2r3V1qui6/YWmlb/8ABFz/AIKF/GvxxqHxf\
+B3xD/Y207UfCPi0+BfE3iHxzr3hH4JfH3wf8Z/gZ4o1/wbrfjnwFpf7EH7FGleGv2WfEep6RpvhTV9\
L0RdQ+Jt34Vu/sGvWXjTxHcTw6lNjhvDaeY4DAZnwf8ASW8NuPcJi8unmFKg8Pxdw/j69KlRpSeHlPP\
snwGXf2lOpVUJYbA18dRhONSMq0KaVVfe52/B3A5jnWTcReDvG/h5m+CrU6dTEU+KckzrAYStiayqUl\
Ty2PDWHxlbK54NzrYTG/25ialal9XqRni4141p/wBwzt9klMjyYtZ2AZSvy287YxJvXhIHIO/PSRg2f\
nYj83vjx4R1X9kL4uXv7ZXwb+HeoeI/h74s0/UdP/bD+HvhTVLm3ubjSkvrDVNK+PHhPwanlWN54w0q\
Ua++t3E8pjltdVublodPOpeI/E1t/Od8H/2nP+C9Gj/FX4u/ss+EPhr4b+Mf7R/7PmjfD3TvEYj+Kc/\
gXxh8RfAWsWGr23iH4ueJtK/bT/bG8T+Fnkk1zTPAjSzfDn4b3mh3Fz46kNl4y8L6XHZ6B4u9x+In7Z\
X/AAXx+Evw0vrP9pD/AIJq/tE/EPTvHGs3vgZNQ+BfxT/Y0/aASz0PxH4fvd6eK/2dPhV+yd401fxjo\
lvbafrhv5bvXNA0fUUurLRrrUtIu7+3urn28L9Hri7xT4XyDO+DM+4VzLGZoqGJyxUuNOC6Wc4XGyw/\
t40K2RY7OqGc4fFUYueFzLB18vhUjJ18DVUa6nFfluKr5l4b8Q4jKeJsqxNGlXo03iaE6GJeFx+XYqE\
KtHEUMVRi6FfD4ilKnisBi6NWdNyVHEU21FI/re0nVtK1/StM13QtT0/WtE1rT7LVtH1jSb221HStW0\
rUbaO80/U9M1CzkeG/0+e0mhlhmid45Y5VdGZWBP5Vf8FI/BvwA+M3jH4KfCn9pq18KW3wL8FeEfjb+\
0v8XtX8Q6L4ptPFOpeB/gz4b0vVpvBfwu8U6NotxLrd3NN5+u+JNE0Fj4jt9L+HtlrNpPpd7baNPd/z\
8fBv/gsh+1x+w94b8QeEPix+wv8AtI/s2fALxF47+1/Cv4g/tL/sofHTQPg/8PfFnjrU9Ljb4V698R/\
Fvxss1+HvgqSWLW7nRpDDrV3carev/aUrjUNS1nTf6Tfiz8Pfgr/wU0/ZTmZLXwlqPjez0nX7HQL7Td\
di8TWfwt+MtvpMVt4k8Bat4x0XQrqLxB4Jl1dLK01V4LK40/xBoj2Wv6RFMsmg6nH8hxDwVxxw1hquW\
cbcL/2DnMlWwtahUccXg/rVOlSnVoqvRbpYin7LFYXEOEZKpLCYzC1ZQhDE0nLiyTNsrwPEeWZrl2Y4\
+GWZdjqOIpYnCy+oZmqNDFaYjCTftFhcWvZSeGr/ALyFOvCM1zcjRxv7DHwa8HfFj9gC68J23jrR9T+\
Cfx01Xx54++BjfC3RfBPhLxN8AfB/ivxAPEXg9rLUPDFrdaL4d/ac8PfFOz1bxrq02jWFnongP4m6pf\
8Ah/wXpWmeGvCPh20t/wAlP2fPEnxp/wCCef7V/wC0N4NsX1v4p/BH9mTUPh1qf7V2p+GNH+Cnw90i4\
X9pHSrAeAk8I+GtN0/Srq/0WGUaL4j8NeHbHTYdP8AXGva/8OrHVBoCTeN/GvV/8E6P2tNd/YL8e3f7\
In7YXxM8G/C/4deD7S18DaX4a8a+H9D8C6l4U8SrrPhbS/CvxLPiW18YQ6Je6ZqqeJ1sPHMOhaDYWdx\
JP4U+L1rbapDrvx18caN87/GXW/2lP2EPjD8T/gJ8c9D8G+P/ANnP4t/tzyftk+FfH2u+KNB03xF+1F\
f+KdVTVbv4X+LtM0W2sdI1zRptP8E6d/wmOm2ngeLS/DnihtHd4v7N8T+BE1X8Ly/HUsDiuC6GJo1so\
xuUzeW5k+Z1IUOfDTeFo14qpNU8LjcS6dTBYiSdKEIewpcjnBw/0L4q4SzLijIfpN4/LMxwHiBwn4gY\
anxpwUpYZYTEZjOjneGhnWa5ZXnhMJPF57w3kixeC4oyqhKOPxVbF/2pjY4lYXEU8T/YzRXM+D/F2he\
OvD1h4n8OXZvNMvzdw4lt7uwvrDUNNvbjTNX0bWNK1G3hu9C1+x1azvbPUNPvYLe/0+9sZ7O+tre7gm\
hj6av2BpptPdH+boVBNEz7HjbZLE25TwA6n/WQSHaSInAGcA4ZVYAlQK4Pxl8XfhP8Odd8EeFviD8T/\
h54E8TfEzVm0D4b+HfGXjXw34Y134ga6t5pOnNovgjSNb1OC48V6sNQ1/QoDbWEdxMJtatItm+5hV/Q\
6zp16UqlSnTqxnVoNKcU03ByipJTje8eaLTSkleLTWjOzEZdj8LhcDjcVga2HwWaRnPDVqlKcKWIjSq\
So1JUKkoqFaNOrCVKcqbkoVIyhJqUWl/I7/wWk/4JzaVplvffFTwxceEPBfwW1mKw07wX4U0LwTpVxJ\
4W+J8njHSfGl5oN74An0O8tPiGlxPpfjLV4Li/e2W08LWeveCNMn0tIvCOn6p+THgv4Efsd/tA654S8\
IWFlc/sjfFC4Q/CLxzZeOY9bf4T/GHxP4Xh0nxprGleH/FfgTV/hlpTfD3TP+ES8KeIBZeL49UtLbTv\
E/ge6bUIdTuI7GD++H9oDTPAWo/CL4gWfxO8Oaf4w8Baj4flsvEPhPU1uEttbmnngh0KGC9somn0bVf\
7ebSfs2owbZ9Onigv4JYZ7SKVP4PfF3w88TfsR/HfXPEPxT0PXvif8F/i38S/iFZ33wvn8A6b4s8Oft\
DfDpLTT/iTpNxdahD8LbDwZqHxX8LeNNR1rVdF8LJDpOsWFwZvD9hdQeG9Z8KtqX5bxtwrlEc0XFGOw\
MsdlGKgqGZxp1cRSr0Kb5KccZRqYadOvyU4RjSx1GMnCphUqqgpU60av7f4YeJPFuHy7DcDZZxhieG8\
wy+vLG8N4n61To4XDZolUq/U6/1hSo01mFVqnl+K5qKwGa1YValWnhsXjK9HI+CnwD/bCs/jb8UfhN+\
zq/7RfiX4Y/s3/ExrNvEv7Pfxx8Q+LvhZpt7LPD4wOhWfwRv/AAY8N9fRa/q1ha+L/DER8TpoN/4hub\
bXNQvLZ4ry99S1/wCFn7bn7JXiv4z/ABv0/wAI/Eix8K/tN+H7j4efGn4P/Gn4Lv4H+CvxS8V3dnO/g\
PXtIh0vwjpOj/DPx14attPvLzwnc6JohOj3+mW85W28Px67Bc+8/s+/swfGb9gH4OWfx1+HnjD9pn4n\
fsCfG6y+JvxQ8J/GD9lXxh8RLz9o34UaXqXw88K6t4H8W/H74a+LrzS9P1X4VW1l8Prxb5rG+8Owm3g\
fVdZ1zw3eHR/C9z+kHg3/AIKi/saWnw/1rxn468f/AB5/bH/bB8SaXa/C2H9kfX9AuPGngXUfj22lQ/\
C3xR4I+CB+GHgG5+Fc+ja4vikQyeINBv8AxRdaj4U8SSnSH1i88QX+la98fRwXB2W06lCrxDmHCebZd\
CpWpQr43EfVI1E5PCyw9KvVxVHF2pVYUaH1VzeJpQqRpx9q68F/VecZH9JLPc9y/HcC8I4Pxq4R44dD\
AVcTRwVDO8Xi1Chh6OeYTiTGV8PhM5yD6xjcFWzTOcLnNXLVlGJrU8x+s01RwWZr94/2efib4S+K3wQ\
+FPxP8FfFjRvjd4R8ZeCPD95b/FjQtMttE07xrqsNlFp2ueJH8PWiqvg69uNfstUXUdFlSK40TUln0y\
6hguLaeKMr+MD4ha9+1n+yz4Z+Of7JWjftH/s//Bb4XftBzftOTfGTTPA3g/RfF/gDwf8AFfU/EXij4\
SweBta8UfFXTba9+GvgnxdN4E0XwTc634h8R2k/h7wt4x0H4s65rFpNF4uu4yvczDxWzvLqWCoT4ExO\
PzanFwx1OnLFQhh8RDltGHssvxnPTq05Qr0qjkk4VIxvOpCry8XhP9Cnwl8WavGOaf8AE0mTcB8NZfj\
3TyZYz+wsVisdgW6kHWrvMOJ+GJ0qlHEUa2GingqdXFUqdHMpYTAYbHYOlPd+Hfij/gpB+2f8HPhL8K\
Pg3+1n+zVpNx8HfCEeveGdD/aa+NV74tn07xD8FNF8Hy+E/jZ+zp4l/Y9/4Jx/Cu907WtG8O6f8RrB9\
H1vxf46vbjTdc1C/XTLbUvD9j4nHnH7WHwL+Pv7QupeAfHP/BQr4V+CfiJD4B+Lnw41D4q/FP8AZ+s9\
Q8FReNfhx4x+Cdp4V/ak8R+KfEcHxCu9Wf4dw6z4d+FF4wbwl4U1Cz0L4CXOg6PNC0vhnUpSiv2TxM8\
SZ5jwquOst4E4Y4S4jy3JIUMTVyrJMPQp5vh0o1fZ5pQrPEUqtde0r0aeaYaGFznDYbEVcLhcxoUPZ0\
4fwtjcpfCHiBnuRZVm2OeGyfN8ZhMPVnipwxEIUcTUw0Zqth/YSU5QhGU4xSozmuZ0rOx+Q37LPxC+I\
dxp3hDxP8BfB/7Z3hHVPh/4jbxFZax+zH481XxLe+A/glqmv+D7H4h6x8e/jH+zJ+zR4x8UfDTxNofw\
t+Mmo32uaz4q+Hus6lJp3h6K1s7CfOk+ELL+gnX/AI/+P9Y+E2i/s6XX7HPx70X9mr4E/s9a9bfCH9p\
D4V/sd/tVfB74A/FKy8WeEfCPieW5+I/xU+N3xA+GWmfD7wZP40tdG8Z+I/iN450zR/Del+JfhcfFeq\
XVz4bmvbvUiiv336F/hT4UfSByzxM42zjw4wHAlV4uWX08v4fxObxwFCH1irTlXp/23meeY+VedLBUq\
dRV8fWw1VSlKph5VIYedHs8Z/FLxJzLM8Rwzn/G+O4jyrAY+tXUMU6EI1sRQdShSxWIo4KhhMNWxUKV\
atCGJnQ9tThVqwpzhTq1ITP+Cbv/AAWb/Zs/4J2eLrn9if8AaL8X/Db4Y/seL8MdR+Lv7O/j7wb48+C\
/7Q+oeBvix4k8dJrnxq/Z/tvDf7Avj74s21r8OLnxR428TeI/DN34i1HSNV09dO1i2Syj8Paj4Y0Dwn\
/Qr4e/4K//ALC3i74TXHx88KeJf2jfE/wLtND8T+J7r40+Hv2CP2+ta+E1t4a8EzatbeM/ENx8RtN/Z\
ll0eHQ9IuNA12PVLtrwW9g+i3aXckTW0wQor/THL/oEeCnGvh3geP8AFZpxDlGb1ONaPCs6WDx+ElQq\
4B4CGMjiq0sdl2OxdbM4qrHDzxtXFzeLp0YYnHQxWZVsZj8V+EZjxbmlPNKtN06E/bYSGLb9lyfvZqP\
OowpSp04U3JykoQhGMHJxhy01GEfVf+HnX/BNj/pIV+w7/wCJZfAX/wCb6voD4O/Hf4IfHnw/e+LfgP\
8AGf4VfHDwRZa/deF7jxZ8IviB4R+JPhnSvFFnYabq174Uv/EHgvV720s9ai0vW9GuRZySrcR22qW7t\
GI5oGkKK/jTxx+jZwN4ZcBYnijIc1zbF4+nicPRUMZXwdSjy1XLmfLRwGHqcyt7rVRLe6dz1sszjE43\
FRo1adOMXFu8VJPS3ebXXsfiP/wVL/Yg+LHg/wAeaz+27+x/4i1r4X6tfeAPFHhL9oKx+GGt/FHwVr1\
1Z60b7UP+FyXJ+E3xM8NXfiGXStWbTtVeCW5m0bTtS0y51/XfD/iO01fxDcWHPJ8GP29PCHgub/god8\
Nv+CgeqftBaX4o+E39ufFbwH4R+DX7MX7L3ibxR4I8MeF9b1PTtQ1rxY/w8+KnhjU/iN4P1+1j07Uob\
rw1NrNvpVtrWl6drrXGn2nh/Viiv8qs34by/B8acQUcFVxGChPKKudUlQxNajHDZjCrVoOvRp0pRpT5\
4znKUMTTxEVOdT2ahCpUhL+z+GPGrjXD+GvDmQ4zD5LxFlGEzaGUezzfh3Is2ryy+rCjiZYenmGY5fi\
czwcPaUqSf9nY3B+1p0aMK/tVSp8vB6t+z1/wUm1b40/CD/gpL8Bvif8ACT4s+HfDmm+D7/x5oPh74m\
aF4q+L/wAePhDY67dW3xZ+Gtpe+Af2CPhdpOqNf+E7XRLWTRtc0K+8SaZrfwu0x7O7bW9F0TSbD+jL4\
Y/Ebwt8afhr4M+KHgi+M/hzxvoGneItIlabTLm+02S6iH2vRtWGl391b22v2F+t5p+p2sdxL9mvbC6t\
HkLxvRRX0nA9KeW47K40cVVq0uKcr/tbEwqz9pFY5zwiqVaTkuaKqrEyVWMpTUvZ0npJVJVPkfGDjfE\
cf4eNXG8OZPw9/qFjHkmBjk+X08vg8v8A9rqQp4iNOUlVlTqUHUpz921TEYmTTdV2479oH9n34SftXf\
CPxb8Efjb4U0/xb4M8UWNzYanY3dpZzXOl3txY3enprOjNqVpPHDdi0vr2MCaGe1vLO+udP1C2vNOvL\
2yn/lh/Yb+JPx3/AOCSf7atz+w98XvhJqs3w0+Jmp/C7wv8KPHOj6xJ4p0TxT8M9HTVtBsdE0Kys/Bs\
viXxj8TNGudZvr7wsliLyTxB4R8Na5pWu2d545sNR1LQCiv2fIqVN8RLLHFPB8R4LNViY2WtXKeH83z\
zAYmDteOIw+IwEsNGbco/UcfmFBw561OrR/IMC3jMlznC13zwyqnDF0H9qnUli8NhKsIt3SpV6eI560\
Ek51aGHnzL2bUv2P8A+Clv7I1/8ePhUf2hf2VdN8Kaj8bbe00zxK3iPQ9A8KeNk+KHgE+A/Fnh2znt9\
JuNKuI/ipaSeF/F8tnf+HRfwaR4+8IaheeGdetPE1vF4d0u3+Df2U4fCH/BRL9nHWP2Af2wR8B7LxP+\
z38RtDtP2eG+EvjXxj4g8O+F9a+HOneOpPBvwN8a2WjeLLWbxhpem/A+yebSLi28azX/AMR/hh4l1W/\
0HxN/wn3w78feLfDxRX5ZxhluDnjsixVWiq0c1xEcsxdGaTo4nC4qE3KNaFrudKdKE6E4yi4S+LnSSX\
9O/Ry424lwvC3ipkWX5lUyyvwDk9XjjIMyw8p08zyTPsixOGp0qmX4hSdOGFzDD4+vhs0wtajXp4mi1\
7P2FR1KlTi/+Cav7WXxP/Za+Lni/wDZZ+NX7PPxN+HWiXnxt+Ium+I28X6r4e1C78FvonhvwLqk3jC2\
8YaL4O0LTfGFr4e+HV54W1b4ha7aXCeH5vDPirw/4y0Gy0HS7g2XiL+qFbaFlDLJcMrAMrLe3ZVlIyC\
CJ+QRRRXrcE5hmGM4fgsfjamOxGBxGKwqrVHH2tWnh686dOVVwjCEqnJFKUowhzNczTk2z4v6UHDfDX\
DnirUlwpkGH4VyniXJ8hzp5bg5Yh4HBYnN8pwuOxdDARxVfE4mlg1iKtSVChVxNd0ISVKE1ShThD8Af\
+C5P/BP3WPjf4M0X9tL4V2Gm658Xf2Xfht4/j8WeFtUiMlz8RfgxHaXXiPV9N0lSslpd61o1u/jN4tL\
lsmfW9O8b6zY2t3Z60NCvLX5p/Yd/YL/AOCUv7dXwn8BeOvh54y1nQviJ4o8G3nizxV8A73xv+zl4h+\
Kvw+i0XXh4T1671rw7o/w0j1AeEjrzWcmmard6ZpxvtO8Q6Td3Flp89+tlGUV+ZcS8L8OV/E/L1jclw\
+Y0+I8I514Voc0Y1aNaEI1aPK4unOUZP2iTcKkm6k4Oo3M/oTwn4r4xzL6IniPm+F40zfh/N/BvNcvo\
ZPicuzDEYWpLAZjhM1xNbLMbFTlRxWCpYqhHEYTmpRxWElUrUqGJhh6s6D+b/ij/wAE/vG+i+LvGnwK\
/Z//AOCk/wC1V8OfBXws8d+MLqf9n/XbfxN4c0j4WnxB418Z3nhg6P4J8GfE7w/bHwtq2jTX+taPr1j\
Fb2evW/iNroQWt3FqVlH88/DzQ9U8eapD/wAEsv2yvFNzrHx61rXvHV9+yJ+0b8X9N8PabqPjfw74w1\
HV9B8IFfGvirSdftbiLV76w8XLomrSS6x4ih1a81vwRp82m694O8AwXRRTw2GwvDuTZDnmTUHg6tbM6\
mW1qDrYmrhK2F+tYnCKEqFetVjTahQpzXsHRiqi0j7NRprw+DOI+I/HbiTjvw+8UM6nxJllLhrG8RUM\
ZPDZfTzXDZplmVLMqFelmNPBxryVWrWq0cV9YdeWIw9SSnP2z9sfVX7G+vft2fAL46ax+xbpfxw1T4O\
+G4L7UYvC/wAFfGGrfCb4T2Xhj4latH4SjtdJ8HfE3xV+yH8Y9NuNJ8RS2XivWrbR9M0vQ9I1PU/F8e\
p6ZfSXmtQx+IPtP4zfsyf8FZfCfjDxx+0R8NP+GULfxxN8IfHHw28XeL9DXx58S/2qvib4Q8W6PodtJ\
ea3q/w4+EHwh8L+JvH/AIe1Dw34auvDl/4b0jwnrS6V4D0TRb4+LbvTLW3vyiuzKeFcNi6nGeVQzTHY\
PBcH42EsthSxLawjWAwuLpKlGtGtGMaE686dKPLy+w/dVFUjKpz/AJ5W8fs/pcP8JvF8D8K5pm/E+U1\
8tzHM6+R0Y5ljsPTx+Ky3nxuJw1TDrGYmph8NQnXxWKhWrYjEU44ivOpVSkfnO/jn48eMv2fvin4j8H\
fsc+H/ANrL9l7xP4I0iD9of9krw9qnwN+AV98D/Gvh/wAGQfDjRPGfwd03Uv2pvjH4s8SfEnVG0nUVm\
n1vwxpUnjnS4rqXULDxRZeJLNdHKKK9XKOD8BxRkeQZ9nGMxGJx+ZYLDVpS/wBnvH2lONR01Ulh5V50\
4zlN0/b1a04c8oqfLypfJ4/xsqZfmeaYTLfDXh3KqWGxOJpTjhHxFhKVaVGvUpxrywmH4hpYGhWlSjS\
p1FgcLhKE1SjUlRdeVWrU/9k='
	$end 'DesignInfo'
$end 'ProjectPreview'
