$begin 'AnsoftProject'
	Created='Fri Jun 21 09:25:15 2024'
	Product='ElectronicsDesktop'
	FileOwnedByWorkbench=false
	$begin 'Desktop'
		Version(2024, 1)
		InfrastructureVersion(1, 0)
		$begin 'FactoryHeader'
			$begin 'geometry3deditor'
				KernelVersion(2, 0)
				ProjectContainsGeometry3D='0'
			$end 'geometry3deditor'
		$end 'FactoryHeader'
	$end 'Desktop'
	UsesAdvancedFeatures=false
	NextUniqueID=0
	MoveBackwards=false
	$begin 'HFSSEnvironment'
		Version(1, 0)
	$end 'HFSSEnvironment'
	$begin 'PlanarEMEnvironment'
		Version(1, 0)
	$end 'PlanarEMEnvironment'
	$begin 'Q3DEnvironment'
		Version(1, 0)
	$end 'Q3DEnvironment'
	$begin '2DExtractorEnvironment'
		Version(1, 0)
	$end '2DExtractorEnvironment'
	$begin 'NexximEnvironment'
		Version(1, 0)
	$end 'NexximEnvironment'
	$begin 'NexximNetlistEnvironment'
		Version(1, 0)
	$end 'NexximNetlistEnvironment'
	$begin 'EmitEnvironment'
		Version(1, 0)
	$end 'EmitEnvironment'
	$begin 'Maxwell3DEnvironment'
		Version(1, 0)
	$end 'Maxwell3DEnvironment'
	$begin 'Maxwell2DEnvironment'
		Version(1, 0)
	$end 'Maxwell2DEnvironment'
	$begin 'RMxprtEnvironment'
		Version(1, 0)
	$end 'RMxprtEnvironment'
	$begin 'MaxCirEnvironment'
		Version(1, 0)
	$end 'MaxCirEnvironment'
	$begin 'SimplorerEnvironment'
		Version(1, 0)
	$end 'SimplorerEnvironment'
	$begin 'IcepakEnvironment'
		Version(1, 0)
	$end 'IcepakEnvironment'
	$begin 'MechanicalEnvironment'
		Version(1, 0)
	$end 'MechanicalEnvironment'
	$begin 'SchematicEnvironment'
		Version(1, 0)
	$end 'SchematicEnvironment'
	$begin 'geometry3deditor'
		Version(1, 0)
	$end 'geometry3deditor'
	ReadVersion=11
	$begin 'EDB'
		Path=''
		LastUpdateTimeStamp=1718954715
	$end 'EDB'
	$begin 'DesignMgrEnvironment'
		CompInstCounter=1
		GPortCounter=0
		NetCounter=0
		Alias('Ieee;Simplorer Elements\\Ieee', 'Std;Simplorer Elements\\Std', 'Basic_VHDLAMS;Simplorer Elements\\Basic Elements VHDLAMS\\Basic Elements VHDLAMS', 'Digital_Elements;Simplorer Elements\\Digital Elements\\Digital Elements', 'Transformations;Simplorer Elements\\Tools\\Transformations\\Transformations', 'HEV_VHDLAMS;Simplorer Elements\\HEV VHDLAMS\\HEV VHDLAMS', 'automotive_vda;Simplorer Elements\\VDALibs VHDLAMS\\automotive_vda', 'example_boardnet;Simplorer Elements\\VDALibs VHDLAMS\\example_boardnet', 'example_ecar;Simplorer Elements\\VDALibs VHDLAMS\\example_ecar', 'fundamentals_vda;Simplorer Elements\\VDALibs VHDLAMS\\fundamentals_vda', 'hybrid_emc_vda;Simplorer Elements\\VDALibs VHDLAMS\\hybrid_emc_vda', 'megma;Simplorer Elements\\VDALibs VHDLAMS\\megma', 'modelica_rotational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_rotational', 'modelica_thermal;Simplorer Elements\\VDALibs VHDLAMS\\modelica_thermal', 'modelica_translational;Simplorer Elements\\VDALibs VHDLAMS\\modelica_translational', 'spice2vhd;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd', 'spice2vhd_devices;Simplorer Elements\\VDALibs VHDLAMS\\spice2vhd_devices', 'aircraft_electrical_vhdlams;Simplorer Elements\\Aircraft Electrical VHDLAMS\\Aircraft Electrical VHDLAMS', 'power_system_vhdlams;Simplorer Elements\\Power System VHDLAMS\\Power System VHDLAMS')
	$end 'DesignMgrEnvironment'
	$begin 'ProjectDatasets'
		NextUniqueID=0
		MoveBackwards=false
		DatasetType='ProjectDatasetType'
		$begin 'DatasetDefinitions'
		$end 'DatasetDefinitions'
	$end 'ProjectDatasets'
	VariableOrders[0:]
	$begin 'Definitions'
		$begin 'Materials'
			$begin 'copper'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				conductivity='58000000'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=false
			$end 'copper'
			$begin 'Megtron4'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3.77'
				dielectric_loss_tangent='0.005'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=false
			$end 'Megtron4'
			$begin 'Megtron4_2'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3.47'
				dielectric_loss_tangent='0.006'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=false
			$end 'Megtron4_2'
			$begin 'Megtron4_3'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='4.2'
				dielectric_loss_tangent='0.005'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=false
			$end 'Megtron4_3'
			$begin 'Solder Resist'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic')
				$end 'PhysicsTypes'
				permittivity='3'
				dielectric_loss_tangent='0'
				ModTime=1677073156
				Library=''
				LibLocation='Project'
				ModSinceLib=false
			$end 'Solder Resist'
			$begin 'FR4_epoxy'
				CoordinateSystemType='Cartesian'
				BulkOrSurfaceType=1
				$begin 'PhysicsTypes'
					set('Electromagnetic', 'Thermal', 'Structural')
				$end 'PhysicsTypes'
				$begin 'AttachedData'
					$begin 'MatAppearanceData'
						property_data='appearance_data'
						Red=27
						Green=110
						Blue=76
					$end 'MatAppearanceData'
				$end 'AttachedData'
				permittivity='4.4'
				dielectric_loss_tangent='0.02'
				thermal_conductivity='0.294'
				mass_density='1900'
				specific_heat='1150'
				youngs_modulus='11000000000'
				poissons_ratio='0.28'
				thermal_expansion_coefficient='1.5e-05'
				ModTime=1499970477
				Library='Materials'
				LibLocation='SysLibrary'
				ModSinceLib=false
			$end 'FR4_epoxy'
		$end 'Materials'
		$begin 'SurfaceMaterials'
		$end 'SurfaceMaterials'
		$begin 'Scripts'
		$end 'Scripts'
		$begin 'Symbols'
			$begin 'CAPC0603X33X15LL03T05'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'COIL-1008CS_V'
			$begin 'main'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=true
				InitialLevels(0, 1)
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0.00254, 0.00254, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, 0.000423333333333333, 0.00254, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'main'
			$begin 'MURA-BLM15-CHIP-2_V'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('2', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('1', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				ModTime=1718954704
				CE=0
				Library=''
				ModSinceLib=false
				LibLocation='Project'
				HighestLevel=1
				Normalize=false
				InitialLevels(0, 1)
				$begin 'PinDef'
					Pin('1', -0.00508, 0, 0, 'N', 0, 0.00254, false, 0, true, '', true, false, '1', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(-0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '1', false, false, ExtentRect(0, 0, 0, 0, -0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'PinDef'
					Pin('2', 0.00508, 0, 3.14159265358979, 'N', 0, 0.00254, false, 0, true, '', true, false, '2', true)
					$begin 'PropDisplayMap'
						PinName(2, 5, 1, Text(0.00508, 0.000635, 0, 4, 5, false, 'Arial', 0, '2', false, false, ExtentRect(0, 0, 0, 0, 0.00508, 0.00113792000000018, 0.000670560000000244, 0.00167640000000061, 0, 0, 0)))
					$end 'PropDisplayMap'
				$end 'PinDef'
				$begin 'Graphics'
					Rect(0, 0, 0, 0, 0, 0, 0.00508, 0.00508, 0, 0, 0)
					Rect(0, 1, 0, 0, -0.00211666666666667, 0, 0.000423333333333333, 0.000423333333333334, 0, 0, 0)
				$end 'Graphics'
			$end 'WE-Coil-PD4-S'
		$end 'Symbols'
		$begin 'DefInfo'
			CAPC0603X33X15LL03T05(1002, 0, 0, 2, '', 1718954704, '', 'CAPC0603X33X15LL03T05', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC1005X05N(1002, 0, 0, 2, '', 1718954704, '', 'CAPC1005X05N', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC1005X33X10LL5(1002, 0, 0, 2, '', 1718954704, '', 'CAPC1005X33X10LL5', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC1005X55X10LL05(1002, 0, 0, 2, '', 1718954704, '', 'CAPC1005X55X10LL05', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC1005X55X23ML05T8(1002, 0, 0, 2, '', 1718954704, '', 'CAPC1005X55X23ML05T8', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC1005X55X25LL05T10(1002, 0, 0, 2, '', 1718954704, '', 'CAPC1005X55X25LL05T10', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC1005X55X25ML05T10(1002, 0, 0, 2, '', 1718954704, '', 'CAPC1005X55X25ML05T10', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC1005X55X25NL05T10(1002, 0, 0, 2, '', 1718954704, '', 'CAPC1005X55X25NL05T10', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC1608X08N(1002, 0, 0, 2, '', 1718954704, '', 'CAPC1608X08N', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC1608X90X35ML10T15(1002, 0, 0, 2, '', 1718954704, '', 'CAPC1608X90X35ML10T15', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC2012X12N(1002, 0, 0, 2, '', 1718954704, '', 'CAPC2012X12N', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC2013X100X20NL20(1002, 0, 0, 2, '', 1718954704, '', 'CAPC2013X100X20NL20', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC3216X180X20ML20(1002, 0, 0, 2, '', 1718954704, '', 'CAPC3216X180X20ML20', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC3216X180X55ML20T25(1002, 0, 0, 2, '', 1718954704, '', 'CAPC3216X180X55ML20T25', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPC3216X190X55ML30T25(1002, 0, 0, 2, '', 1718954704, '', 'CAPC3216X190X55ML30T25', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			CAPMP7343X31N(1002, 0, 0, 2, '', 1718954704, '', 'CAPMP7343X31N', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			'COIL-1008CS_V'(1002, 0, 0, 2, '', 1718954704, '', 'COIL-1008CS_V', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			'MURA-BLM15-CHIP-2_V'(1002, 0, 0, 2, '', 1718954704, '', 'MURA-BLM15-CHIP-2_V', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			'MURA-BLM15AG221SN1x_V'(1002, 0, 0, 2, '', 1718954704, '', 'MURA-BLM15AG221SN1x_V', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			RESC1005X35X25NL8T10(1002, 0, 0, 2, '', 1718954704, '', 'RESC1005X35X25NL8T10', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			RESC1005X40X25LL05T05(1002, 0, 0, 2, '', 1718954704, '', 'RESC1005X40X25LL05T05', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			RESC1005X40X25ML05T05(1002, 0, 0, 2, '', 1718954704, '', 'RESC1005X40X25ML05T05', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			RESC1005X40X25NL05T05(1002, 0, 0, 2, '', 1718954704, '', 'RESC1005X40X25NL05T05', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			RESC1005X40X25NL5T10(1002, 0, 0, 2, '', 1718954704, '', 'RESC1005X40X25NL5T10', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			RESC1608X05N(1002, 0, 0, 2, '', 1718954704, '', 'RESC1608X05N', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			'SMD-0603'(1002, 0, 0, 2, '', 1718954704, '', 'SMD-0603', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			'WE-Coil-744301047'(1002, 0, 0, 2, '', 1718954704, '', 'WE-Coil-744301047', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			'WE-Coil-PD4-S'(1002, 0, 0, 2, '', 1718954704, '', 'WE-Coil-PD4-S', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
			main(1002, 0, 16, 0, '', 1718954704, '', 'main', '', '', '', '', '', '', '', 'Project', '', '', 1718954704, '', 0, 0)
		$end 'DefInfo'
		$begin 'Compdefs'
			$begin 'CAPC0603X33X15LL03T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 0, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 1, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 2, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 3, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 4, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 5, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 6, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 7, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 8, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 9, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 10, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 11, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 12, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 13, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 14, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 15, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 16, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 17, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 18, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 19, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 20, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 21, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 22, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 23, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 24, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 25, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 26, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 27, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 28, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 29, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 30, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 31, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 32, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 33, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'COIL-1008CS_V'
			$begin 'MURA-BLM15-CHIP-2_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 34, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 35, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 36, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 37, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 38, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 39, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 40, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 41, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 42, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 43, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 44, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 45, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 46, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 47, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('2', '', 'A', false, 48, 1, '', 'Electrical', '0')
				Terminal('1', '', 'A', false, 49, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 50, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 51, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 52, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 53, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				Terminal('1', '', 'A', false, 54, 1, '', 'Electrical', '0')
				Terminal('2', '', 'A', false, 55, 1, '', 'Electrical', '0')
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'WE-Coil-PD4-S'
			$begin 'main'
				Library=''
				CircuitEnv=0
				Refbase='U'
				NumParts=1
				ModSinceLib=true
				$begin 'Properties'
					TextProp('Representation', 'D', '', 'main')
				$end 'Properties'
				CompExtID=1
				$begin 'Parameters'
					MenuProp('CoSimulator', 'D', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'D', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
				$begin 'CosimDefinitions'
					$begin 'CosimDefinition'
						CosimulatorType=4
						CosimDefName='DefaultNetlist'
						IsDefinition=true
						Connect=true
						Data()
						GRef()
					$end 'CosimDefinition'
					DefaultCosim='DefaultNetlist'
				$end 'CosimDefinitions'
			$end 'main'
		$end 'Compdefs'
	$end 'Definitions'
	DesignIDServer=2
	MoveBackwards=false
	$begin 'PlanarEMCircuit'
		RepRewriteV2=true
		Name='main'
		DesignID=0
		$begin 'Circuit'
			ComponentName='main'
			AutoFP=''
			$begin 'DesignDatasets'
				NextUniqueID=0
				MoveBackwards=false
				DatasetType='DesignDatasetType'
				$begin 'DatasetDefinitions'
				$end 'DatasetDefinitions'
			$end 'DesignDatasets'
			VariableOrders[0:]
			$begin 'Net'
				NetName='+VREFDDR4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_AVDDL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_AVDLL_PLL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.2V_DVDDL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1.8V_DVDDH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='12V-In'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='1V0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='2V5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='3.3V_AVDDH'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='5V'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='A10_GNDSENSE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='AVCC_1V3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLOCK_I2C_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='CLOCK_I2C_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_A9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ACT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ALERT3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BA0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BA1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_BG0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CAS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CKE'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CLK_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CLK_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_CSN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DM7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ10'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ12'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ15'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ20'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ21'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ22'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ23'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ24'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ25'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ26'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ27'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ28'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ29'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ30'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ31'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ32'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ33'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ34'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ35'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ36'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ37'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ38'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ39'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ40'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ41'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ42'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ43'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ44'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ45'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ47'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ48'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ49'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ50'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ51'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ52'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ53'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ54'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ55'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ56'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ57'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ58'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ59'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ6'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ60'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ61'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ62'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ63'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQ9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS4_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS4_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS5_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS5_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS6_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS6_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS7_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_DQS7_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_ODT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_PAR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_RAS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_RESETN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DDR4_WEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_3V3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='DP_ML_LANE3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_GTX_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_MDC'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_MDIO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RX_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RX_DV'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_RXD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TX_EN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='ENET_HPS_TXD3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GND'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='GND_DP'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TCK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TDI'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TDO'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TMS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='JTAG_TRST'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH01_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH01_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH02_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH02_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH03_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH03_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH04_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH04_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH05_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH05_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH06_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH06_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH07_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH07_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH08_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH08_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH09_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH09_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH10_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH10_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH11_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH11_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH12_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='LVDS_CH12_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC10_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC10_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC177_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC178_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC179_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC180_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC18_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC19_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC19_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC25_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC26_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC26_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC271_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC291_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC33_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC34_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC34_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC35_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC42_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC43_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC50_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC50_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetC9_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetD3_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_7'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC1_9'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetIC2_5'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_18'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ1_19'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_14'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_16'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ2_17'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetJ3_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR100_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR102_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR104_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR105_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR106_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR108_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR113_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR114_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR115_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR116_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR116_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR117_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR119_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR11_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR120_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR121_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR122_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR123_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR124_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR12_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR13_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR1_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR22_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR24_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR25_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR26_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR34_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR65_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR66_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR82_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR83_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR8_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetR99_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_3'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetSW1_4'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU13_1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU13_2'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AP13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AV11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AW11'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU1_AW13'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='NetU9_46'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_CLKREQ_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_REFCLK_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_REFCLK_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RST_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_RX3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_SMB_CLK'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_SMB_DATA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX0_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_CAP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_CAP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_TX3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_USB_D_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_USB_D_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_W_DISABLE_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PCIe_Gen4_WAKE_L'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PDEN'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='PLL_1V8'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK0_FMCB_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK0_FMCB_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK_DP_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='REFCLK_DP_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA__Mod_ABS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RS0'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RS1'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Rx_LOS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_RX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_SCL'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_SDA'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Tx_Disable'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_Tx_Fault'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_TX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_TX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_VCCR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='SFPA_VCCT'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD1_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD1_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD2_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD2_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD3_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD3_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD4_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='TRD4_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_D_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_D_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_C_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_C_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSRX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSTX_N'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_SSTX_P'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='USB3_VBUS'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
			$begin 'Net'
				NetName='VDD_DDR'
				$begin 'Properties'
					CheckboxProp('AlignMicrowavePorts', 'D', '', true)
				$end 'Properties'
			$end 'Net'
		$end 'Circuit'
		$begin 'Layout'
			BlackBox=false
			DefUnits='mm'
			NIdx=5951
			ActLyr='1_Top'
			Tol(1e-08, 1e-08, 1e-12)
			$begin 'HfssExportInfo'
				ScriptFileName=''
				HfssFileName=''
				Version=2
				ExtentType='PolygonExtent'
				BasePolygon=''
				BasePolygonEDBUId=5949
				DielExtentType='BboxExtent'
				DielBasePolygon=''
				DielBasePolygonEDBUId=-1
				DielExt(Ext='0', Dim=false)
				HonorUserDiel=true
				TruncAtGnd=false
				AirHorExt(Ext='0.15', Dim=false)
				AirPosZExt(Ext='0.15', Dim=false)
				AirNegZExt(Ext='0.15', Dim=false)
				SyncZExt=true
				OpenRegionType='Radiation'
				UseRadBound=true
				PMLVisible=false
				OperFreq='5GHz'
				RadLvl=0
				UseStackupForZExtFact=false
				Smooth=true
			$end 'HfssExportInfo'
		$end 'Layout'
		$begin 'Rule Set'
			$begin 'Data'
			$end 'Data'
			$begin 'DRCSolutionMgr'
			$end 'DRCSolutionMgr'
		$end 'Rule Set'
		$begin 'Port'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Port'
		$begin 'Boundary'
			$begin 'Data'
			$end 'Data'
			$begin 'CoupledPortsList'
			$end 'CoupledPortsList'
			$begin 'DiffPairs'
			$end 'DiffPairs'
			TotalVoltage=false
			IncludePortPostProcess=true
			$begin 'SortOrder'
			$end 'SortOrder'
			LegacySolverPinOrdering=false
		$end 'Boundary'
		$begin 'Cavity'
			$begin 'Data'
			$end 'Data'
		$end 'Cavity'
		$begin 'Via'
			$begin 'Data'
			$end 'Data'
		$end 'Via'
		$begin 'LayoutVia'
			$begin 'Data'
			$end 'Data'
		$end 'LayoutVia'
		$begin 'Source'
			$begin 'Data'
			$end 'Data'
		$end 'Source'
		$begin 'Voltage Probe'
			$begin 'Data'
			$end 'Data'
		$end 'Voltage Probe'
		$begin 'DC Terminal'
			$begin 'Data'
			$end 'Data'
		$end 'DC Terminal'
		$begin 'CircuitSources'
			$begin 'Data'
			$end 'Data'
		$end 'CircuitSources'
		$begin 'NexximPorts'
			$begin 'Data'
			$end 'Data'
			$begin 'DiffPairs'
			$end 'DiffPairs'
		$end 'NexximPorts'
		$begin 'SortOrder'
		$end 'SortOrder'
		$begin 'NexximMultiComponentContainers'
			$begin 'Data'
			$end 'Data'
		$end 'NexximMultiComponentContainers'
		$begin 'ComponentConfigurationData'
			$begin 'EnabledPorts'
			$end 'EnabledPorts'
			$begin 'EnabledMultipleComponents'
			$end 'EnabledMultipleComponents'
			$begin 'EnabledAnalyses'
			$end 'EnabledAnalyses'
		$end 'ComponentConfigurationData'
		$begin 'Properties'
		$end 'Properties'
		$begin 'CustomSimSetups'
			$begin 'Data'
			$end 'Data'
		$end 'CustomSimSetups'
		$begin 'RadSetup'
			$begin 'Data'
			$end 'Data'
		$end 'RadSetup'
		$begin 'Setup'
			$begin 'Data'
			$end 'Data'
		$end 'Setup'
		$begin 'AnalysisOptionBlocks'
		$end 'AnalysisOptionBlocks'
		$begin 'EM properties'
			$begin 'Data'
			$end 'Data'
		$end 'EM properties'
		$begin 'OutputVariable'
			NextUniqueID=0
			MoveBackwards=false
		$end 'OutputVariable'
		$begin 'Optimetrics'
			$begin 'OptimetricsSetups'
				NextUniqueID=0
				MoveBackwards=false
			$end 'OptimetricsSetups'
		$end 'Optimetrics'
		$begin 'FieldsReporter'
			$begin 'FieldsCalculator'
				Line_Discretization=1000
				'Show Stack'=true
			$end 'FieldsCalculator'
			$begin 'PlotDefaults'
				Default_SolutionId=-1
				Default_PlotFolder='Automatic'
			$end 'PlotDefaults'
			$begin 'FieldsPlotManagerID'
				NextUniqueID=0
				MoveBackwards=false
				NumQuantityType=0
				NumPlots=0
			$end 'FieldsPlotManagerID'
			$begin 'Report3dInGeomWnd'
				Report3dNum=0
			$end 'Report3dInGeomWnd'
			$begin 'Report2dInGeomWnd'
				Report2dNum=0
			$end 'Report2dInGeomWnd'
			$begin 'AntennaParametersInGeomWnd'
				AntennaParametersNum=0
			$end 'AntennaParametersInGeomWnd'
			AntennaParametersPlotTablesOrder()
			$begin 'EntitySelectionCache'
			$end 'EntitySelectionCache'
		$end 'FieldsReporter'
		$begin 'SolutionManager'
			$begin 'SimDataExtractors'
				$begin 'Version ID Map'
					V=0
				$end 'Version ID Map'
			$end 'SimDataExtractors'
		$end 'SolutionManager'
		$begin 'InterfaceOptions'
			SchematicEnabled=false
			SaveBeforeSolving=true
		$end 'InterfaceOptions'
		$begin 'AdvancedSettings'
			ComputeBothEvenAndOddCPWModes=false
			CausalMaterials=true
			MeshingMethod='Phi'
			EnableDesignIntersectionCheck=true
			UseAlternativeMeshMethodsAsFallBack=true
			CircuitSparamDefinition=false
			CircuitIntegrationType='FFT'
			BroadbandFreqOption='AutoMaxFreq'
			BroadbandMaxNumFreq=5
			SaveADP=false
			UseAdvancedDCExtrap=false
			ModeOption='General mode'
			PhiMesherDeltaZRatio=100000
			SpiceType='TouchStone1.0'
			EnforcePassivity=false
			EnforceCausality=false
			UseCommonGround=true
			ShowGammaComments=false
			Renormalize=true
			RenormImpedance=50
			FittingError=0.5
			MaxPoles=10000
			PassivityType='IteratedFittingOfPV'
			ColumnFittingType='Matrix'
			SSFittingType='FastFit'
			RelativeErrorToleranc=false
			EnsureAccurateZfit=true
			TouchstoneFormat='MA'
			TouchstoneUnits='GHz'
			TouchStonePrecision=15
			ExportAfterSolve=false
			ExportDir=''
		$end 'AdvancedSettings'
		$begin 'CoSimOptions'
			Override=false
			Setup=''
			OverrideSweep=false
			Sweep=''
			FrequencySweepType=0
			Interpolate=false
			YMatrix=true
			AutoAlignPorts=false
			Simulator=1
			InterpAlg='auto'
			Renormalize=false
			RenormImpedance=50
		$end 'CoSimOptions'
		$begin 'TemperatureData'
			IncludeTempDependence=false
			EnableFeedback=false
			Temperature='22cel'
		$end 'TemperatureData'
		$begin 'UserDefinedSolutionMgr'
			NextUniqueID=1000000
			MoveBackwards=false
		$end 'UserDefinedSolutionMgr'
		$begin 'DatasetSolutionMgr'
			NextUniqueID=2000000
			MoveBackwards=false
		$end 'DatasetSolutionMgr'
		Notes=$begin_cdata$ $end_cdata$
		$begin 'AnimationSetups'
		$end 'AnimationSetups'
		CacheHeaderFile='HDR6CBA363617189547153.tmp'
	$end 'PlanarEMCircuit'
	$begin 'DataInstances'
		DesignEditor='TopLevel'
		Refdes('0', 'U1')
		$begin 'CompInstances'
			$begin 'Compinst'
				ID='0'
				Status='Status'
				CompName='main'
				GatesInUse()
				$begin 'Properties'
					TextProp('ID', 'SRID', '', '0')
				$end 'Properties'
				$begin 'Parameters'
					MenuProp('CoSimulator', 'OHD', '', 'DefaultNetlist', 0)
					ButtonProp('CosimDefinition', 'OHD', '', 'Edit', 'Edit', 40501, ButtonPropClientData())
				$end 'Parameters'
			$end 'Compinst'
		$end 'CompInstances'
		$begin 'Instance'
			DesignEditor='main'
			ID='0'
			$begin 'PlanarEMItem'
				Editor3D=true
				$begin 'PostProcessing'
					DesignInstanceID=1
					$begin 'WindowPosition'
						$begin 'EditorWindow'
							Circuit(Layout(View(WindowPos(3, -1, -1, -16, -72, 0, 0, 324, 88), Extent(-3.06630444526672, -1, 3.06630444526672, 1, 14294.3901877805, 14289.1680718094, -0.0477049872279167, 0.0901622250676155, 0.230649910867214, 0.104624703526497, 1), ViewingXfm(-2.20454549789429, 2.20454549789429, -1, 1, 255.771438598633, 273.350341796875, 19.1159439086914, 0, 0, 0, 0, 19.1159439086914, 0, 0, 0, 0, 19.1159439086914, 0, -1.29261958599091, -0.72353607416153, -264.577545166016, 1))), Layout())
						$end 'EditorWindow'
					$end 'WindowPosition'
					$begin 'ReportSetup'
						$begin 'ReportManager'
							$begin 'Reports'
							$end 'Reports'
							NextUniqueID=0
							MoveBackwards=false
							$begin 'NextVersID'
								NextUniqueID=0
								MoveBackwards=false
							$end 'NextVersID'
						$end 'ReportManager'
						$begin 'Reports'
						$end 'Reports'
						$begin 'ReportsWindowInfoList'
						$end 'ReportsWindowInfoList'
					$end 'ReportSetup'
				$end 'PostProcessing'
				$begin 'Properties'
				$end 'Properties'
				$begin 'UserDefinedDocument'
					$begin 'Data'
					$end 'Data'
				$end 'UserDefinedDocument'
			$end 'PlanarEMItem'
			$begin 'TopLayout'
				DefaultUnits='mm'
				DefaultAngleUnits='deg'
				MajorSize='10mm'
				MinorSize='1mm'
				PixelSnapTolerance=20
				SnapAcrossHierarchy=true
				SnapTargetVertex_on=true
				SnapTargetEdgeCenter_on=true
				SnapTargetObjCenter_on=true
				SnapTargetEdge_on=false
				SnapTargetElecConnection_on=true
				SnapTargetIntersection_on=false
				SnapTargetGrid_on=true
				SnapSourceVertex_on=true
				SnapSourceEdgeCenter_on=true
				SnapSourceObjCenter_on=true
				SnapSourceEdge_on=false
				SnapSourceElecConnection_on=true
				ConstrainToGrid=false
				DirectionConstraint=0
				defaultholesize='25mil'
				anglesnap='5deg'
				$begin 'NamingConvention'
					OptionUseNamingConvention_PadPort=false
					OptionNamingConvention_PadPort='$REFDES_$PINNAME_$NETNAME'
					OptionUseNamingConvention_EdgePort=false
					OptionNamingConvention_EdgePort='$NETNAME'
					OptionUseNamingConvention_PointPort=false
					OptionNamingConvention_PointPort='$POSTERM_LAYER_$NEGTERM_LAYER'
					OptionUseNamingConvention_PinGroup=false
					OptionNamingConvention_PinGroup='$REFDES_GROUP_$NETNAME'
					OptionUseNamingConvention_PinGroupPort=false
					OptionNamingConvention_PinGroupPort='$REFDES_$GROUPNAME_$NETNAME'
					OptionUseNamingConvention_PointISource=false
					OptionNamingConvention_PointISource='I_$POSTERM_NETNAME'
					OptionUseNamingConvention_PointVSource=false
					OptionNamingConvention_PointVSource='V_$POSTERM_NETNAME'
					OptionUseNamingConvention_PointVProbe=false
					OptionNamingConvention_PointVProbe='VP_$POSTERM_NETNAME'
					OptionUseNamingConvention_PointDCTerm=false
					OptionNamingConvention_PointDCTerm='DCT_$NETNAME'
					OptionUseNamingConvention_PinISource=false
					OptionNamingConvention_PinISource='I_$REFDES_$NETNAME'
					OptionUseNamingConvention_PinVSource=false
					OptionNamingConvention_PinVSource='V_$REFDES_$NETNAME'
					OptionUseNamingConvention_PinVProbe=false
					OptionNamingConvention_PinVProbe='VP_$REFDES_$NETNAME'
					OptionUseNamingConvention_PinDCTerm=false
					OptionNamingConvention_PinDCTerm='DCT_$REFDES_$NETNAME'
					OptionUseNamingConvention_GroupISource=false
					OptionNamingConvention_GroupISource='I_$REFDES_$NETNAME'
					OptionUseNamingConvention_GroupVSource=false
					OptionNamingConvention_GroupVSource='V_$REFDES_$NETNAME'
					OptionUseNamingConvention_GroupVProbe=false
					OptionNamingConvention_GroupVProbe='VP_$REFDES_$NETNAME'
					OptionUseNamingConvention_GroupDCTerm=false
					OptionNamingConvention_GroupDCTerm='DCT_$REFDES_$NETNAME'
					OptionUseNamingConvention_NCPortInstPort=false
					OptionNamingConvention_NCPortInstPort='$REFDES_$PORTNAME_$TERMNAME'
				$end 'NamingConvention'
				$begin 'TextStyles'
					TextStyle(N='<DefaultAnnotation>', F='Arial', Hght=12, Scale=false)
					TextStyle(N='<DefaultPlotter>', Plot=true, F='RomanSimplex', Hght=5, HghtUnt='mm')
					TextStyle(N='<DefaultMeasure>', Plot=true, F='RomanSimplex', Hght=1, HghtUnt='mm')
				$end 'TextStyles'
				$begin 'TraceStyles'
					TraceStyle(name='Half Grid', size='0.5mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='1 Grid', size='1mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='2 Grids', size='2mm', bendStyle=0, capStyle=0, capStyle=0)
					TraceStyle(name='5 Grids', size='5mm', bendStyle=0, capStyle=0, capStyle=0)
				$end 'TraceStyles'
				'current via style'='PlanarEMVia'
				'current pin style'=''
				MajorColor=14599364
				MinorColor=15391450
				ShowGrid=true
				PageExtent(-0.1, -0.1, 0.1, 0.1)
				'background color'=16777215
				DefaultToSketchMode=true
				fillMode=false
				DocVisibilityFlag=962
				FastViewTransforms=true
				StartingHierarchyLevel=0
				EndingHierarchyLevel=-1
				SingleLevelView=false
				DesignMode=1
				Is2dRendering=false
				'show connection points'=false
				'draw rats'=false
				'display vertex labels'=false
				ColorByNet=false
				'display package graphics'=false
				'rectangle description'=0
				snaptoport=true
				autoplacecomp=false
				AutoScale=true
				'measure display digits'=3
				'display measure units'=false
				SuppressPads=true
				AntiPadsOption=0
				TextIsVisible=true
				'primary selection color'=255
				'secondary selection color'=3289780
				'preview selection'=false
				AllowDragOnFirstClick=false
				PinConnectivityPopup=false
				CreatePortsOnComp=false
				OptionUseNamingConvention_PadPort=false
				OptionNamingConvention_PadPort='$REFDES_$PINNAME_$NETNAME'
				OptionUseNamingConvention_EdgePort=false
				OptionNamingConvention_EdgePort='$NETNAME'
				OptionUseNamingConvention_PointPort=false
				OptionNamingConvention_PointPort='$POSTERM_LAYER_$NEGTERM_LAYER'
				OptionUseNamingConvention_PinGroup=false
				OptionNamingConvention_PinGroup='$REFDES_GROUP_$NETNAME'
				OptionUseNamingConvention_PinGroupPort=false
				OptionNamingConvention_PinGroupPort='$REFDES_$GROUPNAME_$NETNAME'
				OptionUseNamingConvention_PointISource=false
				OptionNamingConvention_PointISource='I_$POSTERM_NETNAME'
				OptionUseNamingConvention_PointVSource=false
				OptionNamingConvention_PointVSource='V_$POSTERM_NETNAME'
				OptionUseNamingConvention_PointVProbe=false
				OptionNamingConvention_PointVProbe='VP_$POSTERM_NETNAME'
				OptionUseNamingConvention_PointDCTerm=false
				OptionNamingConvention_PointDCTerm='DCT_$NETNAME'
				OptionUseNamingConvention_PinISource=false
				OptionNamingConvention_PinISource='I_$REFDES_$NETNAME'
				OptionUseNamingConvention_PinVSource=false
				OptionNamingConvention_PinVSource='V_$REFDES_$NETNAME'
				OptionUseNamingConvention_PinVProbe=false
				OptionNamingConvention_PinVProbe='VP_$REFDES_$NETNAME'
				OptionUseNamingConvention_PinDCTerm=false
				OptionNamingConvention_PinDCTerm='DCT_$REFDES_$NETNAME'
				OptionUseNamingConvention_GroupISource=false
				OptionNamingConvention_GroupISource='I_$REFDES_$NETNAME'
				OptionUseNamingConvention_GroupVSource=false
				OptionNamingConvention_GroupVSource='V_$REFDES_$NETNAME'
				OptionUseNamingConvention_GroupVProbe=false
				OptionNamingConvention_GroupVProbe='VP_$REFDES_$NETNAME'
				OptionUseNamingConvention_GroupDCTerm=false
				OptionNamingConvention_GroupDCTerm='DCT_$REFDES_$NETNAME'
				OptionUseNamingConvention_NCPortInstPort=false
				OptionNamingConvention_NCPortInstPort='$REFDES_$PORTNAME_$TERMNAME'
				useFixedDrawingResolution=false
				DrawingResolution='0.002mm'
				$begin 'ViewConfigs'
					ViewConfigsCurrent=''
				$end 'ViewConfigs'
				currentTextStyle=0
				currentTraceStyle=0
				prevBounds(-3.06630444526672, -1, 3.06630444526672, 1)
				prevMapFactor(14294.3901877805, 14289.1680718094)
				prevOrigin(-0.0477049872279167, 0.0901622250676155)
				prevViewExtent(0.230649910867214, 0.104624703526497)
				prevZoomScale=1
				$begin 'Animation'
					LabelColor(R=230, G=230, B=230)
					FontName='Arial'
					FontHeight=60
					FontWeight=400
				$end 'Animation'
			$end 'TopLayout'
		$end 'Instance'
		$begin 'SODInfo'
			$begin 'CAPC0603X33X15LL03T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC0603X33X15LL03T05'
			$begin 'CAPC1005X05N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X05N'
			$begin 'CAPC1005X33X10LL5'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X33X10LL5'
			$begin 'CAPC1005X55X10LL05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X10LL05'
			$begin 'CAPC1005X55X23ML05T8'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X23ML05T8'
			$begin 'CAPC1005X55X25LL05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25LL05T10'
			$begin 'CAPC1005X55X25ML05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25ML05T10'
			$begin 'CAPC1005X55X25NL05T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1005X55X25NL05T10'
			$begin 'CAPC1608X08N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1608X08N'
			$begin 'CAPC1608X90X35ML10T15'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC1608X90X35ML10T15'
			$begin 'CAPC2012X12N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC2012X12N'
			$begin 'CAPC2013X100X20NL20'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC2013X100X20NL20'
			$begin 'CAPC3216X180X20ML20'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X180X20ML20'
			$begin 'CAPC3216X180X55ML20T25'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X180X55ML20T25'
			$begin 'CAPC3216X190X55ML30T25'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPC3216X190X55ML30T25'
			$begin 'CAPMP7343X31N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'CAPMP7343X31N'
			$begin 'COIL-1008CS_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'COIL-1008CS_V'
			$begin 'MURA-BLM15-CHIP-2_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'MURA-BLM15-CHIP-2_V'
			$begin 'MURA-BLM15AG221SN1x_V'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'MURA-BLM15AG221SN1x_V'
			$begin 'RESC1005X35X25NL8T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X35X25NL8T10'
			$begin 'RESC1005X40X25LL05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25LL05T05'
			$begin 'RESC1005X40X25ML05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25ML05T05'
			$begin 'RESC1005X40X25NL05T05'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25NL05T05'
			$begin 'RESC1005X40X25NL5T10'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1005X40X25NL5T10'
			$begin 'RESC1608X05N'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'RESC1608X05N'
			$begin 'SMD-0603'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'SMD-0603'
			$begin 'WE-Coil-744301047'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'WE-Coil-744301047'
			$begin 'WE-Coil-PD4-S'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'WE-Coil-PD4-S'
			$begin 'main'
				$begin 'CosimDefinition'
					CosimDefName='DefaultNetlist'
					$begin 'SODInstanceMap'
					$end 'SODInstanceMap'
					SODComponentList()
				$end 'CosimDefinition'
			$end 'main'
		$end 'SODInfo'
	$end 'DataInstances'
	$begin 'WBSystemIDToDesignInstanceIDMap'
	$end 'WBSystemIDToDesignInstanceIDMap'
	$begin 'WBSysIDSysDetails'
	$end 'WBSysIDSysDetails'
	$begin 'WBConnIDConnDetails'
	$end 'WBConnIDConnDetails'
	$begin 'WBMaterialGuidDetails'
		WBMaterialGuidMap()
	$end 'WBMaterialGuidDetails'
	$begin 'MinervaProjectSettingsBlk'
		MinervaRemoteFilePath=''
		FolderContainerString=''
	$end 'MinervaProjectSettingsBlk'
$end 'AnsoftProject'
$begin 'AllReferencedFilesForProject'
$end 'AllReferencedFilesForProject'
$begin 'ProjectPreview'
	IsEncrypted=false
	Thumbnail64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCABgAGADASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+q/xDoGhQaFrlzDoukw3EOk6nPFcRadZxzRTR2\
c8kc0cqQhklVwGDAggjIOa1v+EZ8Of9C/on/gqsP/kesnxDotnDoWuXCTasZItJ1OZVl1/XZ4S6Wc7g\
SW02otHNFkDKOjIwyrKVJFa3/CP2H/Pxrf8A4U3iP/5a197bV+6n/W+2/wDkvlzmR4f8P6DcaDolxca\
JpE88+kabNNNNptnLLNLLZwvJLLI8JMkjOzFmJJJJJOaNE8P6DPZzPNomkTOur+IIVeXTbORhFb69qV\
vbxBnhJEaQRRoi9FSNVUAACjw/olnPoOiTPNq6vNpGmyusPiDXreINJZwuwit7fUljgjyTtRFVFGFVQ\
ABRomiWc1nM7zauCNX8QRAReINegXbBr2pQoSkOpKGkKRqXcjfI5aSRmkZmMpX5dE7q+vXbV+f3+oCQ\
eHtAOv6nCdD0cwx6PocscR0yyMaSTXviFJZEjMGFdlghDEDLCFQchRhZvD+grr2m266JpAgl0jW5pIR\
ptmIpJYLzw+kMrxiHDyIlxcBWIyoncAgM2Ug0OyOv6nEZ9Y2po+hyAjxDr4kLS3viFWDzDU98iAQptV\
mKoSxQKXct/Nd/wcT+Ivjd4BX9nLVfgZ+0j8fPgHP4f+GPx68Za3D8Kfi78UvBlt48u7v9o3/gnx8Dd\
FsPGB8HeN9MudQ0/TLH49+JNTtQLhWS5tBHuWC4uM8+LrrB4PF4yVLmp4KnVrTUbc3s6MXUqWukm+SE\
rK+tkup0YLDzx2ZZPlVKUYYnPMdgcuoOTah9YzHGUMDhudpNxg6+Ipqc7PkheVnY/pS1Lw/oMV54fSP\
RNIjS41eaG4RNNs0WeJdB1u4WKZVhxLGJ4IXCtkb4VbGVBBrfh/QYLOF4dE0iF21fw/CzxabZxsYrjX\
tNt7iIskIJjeCWRHXoySMrAgkV/Dh+zr8Ff29PHP7QHxW/Zj+Iv7e37Wnjz4weA/jj8Jfg94Xufh//A\
MFIPj58Pfhet740+DP7bnxa8Xa5q3xEsF+J8889rov7KEVlbWNvo1rqFre+LbrTdet9MvbS6t7b9NNU\
/wCCTv8AwUZgtonl/a+/alkVtR0eELJ/wWr/AGr7hRJcatZW8Mgjb9ghNsiTSoyvkmJkEgVygRvoOHu\
Hc84lyDLuJMFQwOBy7N41p4dZhnOTZbiJQoYitg6kvquOx1DExisThq9NN0kpSpy5b2Z6fF+RYvgriP\
MeGM1qU8Xj8s9h7SpgpPFYaSxGHo4qnKliKcfZ1Yyo16clODcXf3W1Zv8Apb8QeH9Bt9B1u4t9E0iCe\
DSNSmhmh02zilhlis5njlikSEGORXVSrAgggEHNa/8AwjPhz/oX9E/8FVh/8j1/BH8X/jR4b+DHxR+J\
nwM+KP8AwVN/an8L+PPhrq83grxVY3//AAVW/wCCiWt6PF42h1bxZoGueEDcaJ/wTJnWefTrrwwJL+6\
lMGjNaeItOmtdVuI7iVrf6W+A/wAPPib+1Fe+O9P/AGcv+CkX7WXxvuPhldaPZ+O3+GP/AAVi/wCCiP\
jCz8NzeIZteg0FrzUdF/4Jhy28ltev4Y182k0MskNyulSvDI6AMfQhwdm9SFSrTzDh+dGjy80lxXww4\
RbaS5pLNuVO7irN3u491f5LPc3wHC8lDiarLh2bi5cuOhLCPlU403K2IVN8qqSjT5tudqF+ZpH9l3h7\
w9oE+gaHNNoejzTTaPpksssumWUkkskllA8kkkjwEu7MSSSSSSSeaXTfD+gy3niBJNE0iRLfV4YbdH0\
2zdYIm0HRLhooVaHEUZnnmcquBvmZsZYk/wAfnhn4cfET4K/tI/Cn4R/tdfti/wDBSX4YeAvjN8GfGl\
38HfFlp+3V+3F428IfEn48aP4m+HNn4d+DWjahefCD4Z6n4J8VDw1q2tTRJc6XrGi6w3iTTLPTdYTV7\
ZtOvPrf4deDf2WviRoM/i3wP+3J/wAFp/Hfhu81W9sLbxd8JZP+Cw3xY8CaxqGhCHQ/EK6L8R/h14e1\
HRfGMVn4j07VtP8At2nXk9rKNJBhkeMKzeJjch4uwXtZ4fhGvnuAoSw9P69lmKyzMcBUniMP9ZpxpY3\
B42th6slBVIVFCpJ0sRh8ThqnLiMLXp0/C/11yavj8Bl2UN8QYjMcveZ03g6uDnD6osfist55Tq4qik\
/reCxFOMdeb2bcW+WfL/SX4h0y9j0DXJH8Q6xOqaPqbtDLBoAjmVbKcmKQw6GjhGAIOx1bBO1lOCNj+\
yr/AP6GbW//AAH8Of8AzP1k+IZtdOha4s2naTHbnSdTEssWtXk0yQmznEkkdu+gIssoTJCGRAxG0uoO\
4a32jxH/ANArRP8AwoL/AP8AmZrksk3v0/m/r+n5n15j+HtMvZNA0ORPEOsQK+j6Y6wxQaAY4VaygIi\
jM2hu5RQQBvdmwPmZjkk0PTL17Kcr4h1iEDWPEKFI4NAKlo9f1ON5SZdDY73ZS7YIUNIQiom1FXw/Nr\
y6Doi2+m6RLANI00QyTa3eQSyRCzhEbywp4fkEMhTaWUSOFJIDsBuJok2vCzmEOm6RIn9r+ICzS63eQ\
sJW17UmuECJ4fcGNZzIqNuBdEV2SMsY1mKXub6Lz8tvL00ASDTL06/qcY8Q6wGXR9DczCDQPMkV73xC\
FicHQygRDG5XaisTO29mAQJ+I/8AwVx8OX178RfCc6Wfg3x5eeGf+CZn/BWT4haP4Y+Lvw3+HnxR8D6\
p4o+Glx+w9488Ex6t4J8YaDJo2qi38c+H/DN/C2p2d9bwXOiwS/Z2Kk1+3EE+v/2/qZGmaOZjo+hiSM\
65eiNYxe+ITE6Sjw8S7sxmDKUUKI1IZy5CfkV/wUesdV1349eAtGvrDT4YtX/4Jhf8FeNKmNprlz5gs\
9RtP2KbS8mjnm8OERXSJKhiBikRixL7QgV1UxFPCYXH4qabhh8Ni5yTUpLljh6rej3dlpbW+zT1OTEQ\
o1MXw5SxMnDDVc8yCFSSjCclTlneXxm4xqwqU5SUW3FThOPNa8Xsfy23fwb/AOCp3wV+Mx0v4p+Bl/Y\
Y+HHwc1Pxb471745fszfs3fs2fA211nXPD/7C37UHxvtbvwLP8C/DvhjRf2kPH+i/Cbwt8aNIjsotav\
8ASNB1TxHf+G77xR4bj8TXN9P926r8S/2jvDv/AAR+8dftoal+33+1n4i/aH+Ffxsl+CHxE0DTPG2o/\
En4e+E/Gdp+07o3gW6uD4h+G1za6F4o06x+DviDRNZ07XrDWo/C+qatPp1pFqstxepZS/sn8Uvj1aav\
4Q/Zd8XftF6/8HPid8Mvg3+058Vn8f8Axh8Hy3XjL4XfG34ISf8ABJL9rX41J8UT4Q0HwjqEF7pOr/B\
j4g2s+paZo6a3p9/d290mjJcabfWkMX5H/wDBdi2+DHxa/wCCd/wo+IX7K+paH8MP2fP2ZP2j/G/wX8\
R/s7eHPhb8Qvgd4e074x+NJ9M1G9u9S+E3ivwh4P8A+EN8ceHLuDxhBsvfDk8sx+NGtPBPaXE119s9z\
jTD8VeGuT8NZRlPHmbZhhXk2KxlLD0s4xcaThiM2xdOGLwLhUwtSngpYeisw9lUpxre3xeIl7OlWr+x\
h/UOWcZ8V4fOsZwvXx+F4Wy6rm2HdPMMowap5ROhisvnisNQoU4YVTjLNqcsD9TqYhUqtCko1cXToTW\
NqS/jk/aX1j4s/EbxR4Z+OPxkudCuvGH7QPhTUvifJqGhaL4c0WTX18P+NfHXwd1vxP4kt/DlpAL/AM\
Zaj4w+EHie81jU70T6lrWo6hda9qd3eajqd3eXPQfsO/E3wP8AB39tD9lT4k+N9ePhv4c/Dv8Aau/Z9\
+JHjDxvdaNeX2p+HPA3w/8Ait4f8QeIdZ/sjR4dRmumj8PQX91NZ2trf3Ms2mwQ2qzsTHL45rcF94iv\
fEPiLRfBGoWvhTwjqTSeKL3TdN1DxF4f8OvqnivxDcaFbXOoXnz6Ppdw+ox2MMF9qE0t3JZNIbieXZH\
F6r8UfgB8Xfhz4B0/4pfET9mb4tfDr4d/FDQPDB+CHxB8XeAvF/gjw34j0WztfDDW3i/TL/UtMtrHxh\
/avhlbS6e6sxLa3E3jMX6SEXFkW/Iq2OliquElTy2tUnX5J1uSr7bmrxdCUq1SVRRqc9TnnjqiVWo40\
J+9Fz5Yy+IxOTzzfHZ9mmCzWj9ewdOrUn7SjjnUq0aGV4ypj501RpV404+1w0sG6ssPQwlPGVoujVwu\
Aw9WtS/tr/4KTftPfAD/AIKC/s/+J/h9+xv8b9E+Pni/Tf2e7HwXqXh3w29rpcGk+J/ih+3f/wAE2dA\
8B6Dd6l4l0LTobRL/AFfSNTjjmmu/LiOkF7q4ii3tJ/DB+0CP2gJ/i341k/aN8OePfD/xesNP8JTeKv\
D/AI98C3fw+1zwl4ej8L+FNN+HenL4Dn0Swj8B+B7bwBN4KsvDem2thY6TY6G+j2ej20GmixhH6Zf8E\
l/HVx8IJviJ481PV/A//CutR1L4AWnxEtbvxZp2n+MPCFj4M/bn/Yu+J9h4yXwrF4Tn1bxdbfYfBHiK\
1h03TLq7u5rbVdQ1WDTvJ0HUHm+e/wBu/wD4Trx5+2b+294ulv8Axh8VbPxv8QfFVt4I8bWaeIvHWk6\
x4XsviP4UuPBOheG/FUK3cV94R0f4faDY6Vo7RzJZQ6X4Zs7Syjt4EtrRP6qzDB8R1/ADh2nlmExuXc\
L1eNeJ8dShGvVxPPiq/BvB1GEcVKjDD4aVeLy5ywkXhYYrDUMfZzksRDn+d4p4ezfHcbcEYDAcIY3Cc\
Kx4Cp47C46u6GMq1K1XPOJcUqFLEYaMIypVq69hKlPDYWvCrQip0pxq4WtX/wBYjxDqN5JoWuRPoGrQ\
RvpOpxtcyzaEYYUaznUzyLDrTyGJQSxCRs+AdqM2FOt/at//ANCzrf8A4EeHP/mgrJ8Q61ZzaFrlukO\
rCSXSdThVpdA12CEO9nOgMlzNpyxwxZIy7uqKMszBQTWt/wAJBYf8++t/+Ez4j/8AlVX4zdXfv2+77v\
67+h8EZHh/UryLQdEjTw/q9wkekaaiXEM2grFOqWcKrNEtxraSCNgAyh0R8MNyqcgGialeR2cyp4f1e\
cHV/EDl4ptBCq0uvalI8JE2tofMjd2jcgFC8TGNnj2ux4f1uzg0HRIXh1dnh0jTYnaHw/r1xEWjs4UY\
xXFvprRzx5B2ujMjDDKxBBo0TW7OGzmR4dXJOr+IJQYvD+vTrtn17UpkBeHTWCyBJFDoTvjcNHIqyKy\
iV9nW1l922n/D66AJBqd6Nf1OQeHtYLNo+hoYRPoHmRql74hKyuTrgQo5kcLtdmBgbeqgoX/Ez/gqjf\
8AxD8RftLfs0/CX4bfDz4m+IviB+0H+w1/wVW+A/hK18A6h8KtN8TaRqnjzQP2SJB4sttd8e/Gbwvp3\
h2DTINGmuDejULq9hnNubTSb9jJ5P7Zwa5ZDX9TlMGsbX0fQ4wB4e18yBor3xCzF4Rpm+NCJk2syhXI\
YIWKOF/MD9p/WLST/grB/wAEpZ1h1QJbfCX/AIKReYsmh63FM3neD/2Z0TyLaXTxJdYI+bylfYPmfap\
BqlH2kK1JVuX21OtBu1OTSnTnGTUakJwbs3bmjJX1tseVm+K+pUsuxn1eninhszyiap1VKVOTjmuDaU\
1GUJNXSdlJbbn81PxZ+FP7Z/8AwTs/Zkg0D4m/BH9oDxB8PvGGp23gHw1J+0r+13+yx4x8O+FPEGnf8\
E0/2zf2a9b074U+BtN+IWow6tqV34P8djUtB8Fx2ouNY034KeHPhvaX2p6jNpV2/wCJusftQ/FzxV+y\
xo37MmoeAvjvb+AbTxFYeL00rRfCenjwtqWv2/xDm8YWvi/W9Js/BdlH44+IM2i3EemSeJdWe51SS1E\
Fm8s2lWVppq/3Wf8ABdH4S2f7SHwB/Zo+GQ8FfHzxV9v/AGvtGubS6+C/w38aeKdX8EeJH/Zq/ad0n4\
f/ABA8d6TovgDWdQPwZ0v4k6t4Ol8YzaZp9xq1v4elv5tJin1NLS2n/mV+AP7XPjzwN8Q/hr8D/wBqf\
9q39uT4GfCnwVqOk/Db4meGvBPxR+MfhXxx8JLbwnbjQbG0sPClxPcjw5ZaJrem6Ubuwt9Mmv7XS9Ou\
bax0579YLM/lfHPHPE3B+I4Zw1HPsXjJ4nC4jJ6Fd0MHKdDLsViXiMTTrzpfVKdLDTr4mpy1pUXUjTV\
Wkq0aNKNNf6V/RW4Xo+IfDvi9xFSzPKsnxuDyycMXlmKp0631rDwwNTD0P7Hlj8uzbHQzWph6FXBYeG\
BxEKkItfVJU6s6sF+Ifw91n4aeHPB/grw38Qv2cvive/EXwbf6nd2/iTwxpf8AwjGpXN/qOvPrWjXN9\
NZafa6hrFxbQ/2ZHbLfzXPkC3ItDDFM0Z+3P2lv+CjPxf8A2hPh1Z/Cb45S/td+LPCHiTxx4DmTw18W\
fGd7faTqdxpXijTb6/j0ew1aEzDXJNAj1i0hubNRNbtq4RpI1nw/7EfGz9ln/gjG/gmC8/Zz/bq+IM3\
jm28T6Hq9/o3xVf4kQ+HPGXhJ57mPxToWneMPDP7M1xceBPFM1nqDXunaxJpWv2IvdMit9Q0a4t7t7u\
z+Jvij4y+LWoftIfsR3/i79t34OftgXWg/Fm+t49W+P3j79pHxP+zj8PfD3iLUfCWk+JrP4+D41/DPQ\
M+FPEK3ekWcVjognbUP7BdtSXy7O3Sf9i4I4749wdHJqsMXgvqVSjQw2Op0cUsPi6mHhQ9jCNCpQx+I\
WKw+HpTkvfw0VPC3jem6laVH6jOOIsFwv4WcZ0OC8Xh6zy/JJYCMcz4Ay3A4zHYLBYOOBjQx+Nr8NPF\
YqtPLJTp1MxxGJpqD9pL/AGiUfYT+ZfgZ8OvhjfSNpfgLwP408OeCNVsNMm8T2njN7mbVfE114OuH1e\
Hw3pbX3ixbnwZpWmeJ/GOi6pNLbRSR6zdu8O+OC2na/wDnb9qvSLGx+Oen6R4U+A9jH4Sh03wnpfibX\
LC/8e6lcDVbjTdPtbjVtVvI/FlzDo8RimsLtvPRY5Zpr2O2lgtEt7TTfXfFPifWfhP8d9V8HfDfxv8A\
Cz4iXej6T4t0fVfFHwu+IOh/ET4WXOkanceHLvQvFHh3xVocl9b6/GFit5bW2dk1K1kuha6zb2UovrU\
eea98X/EEkdrrvjPQvDOt2zx22jan49v4tO067GrNNa2WmTeKdOsNNtrWOzkW8toft8bwwxCBIZ4baJ\
FuG/tn6R/jfjOF/A/gTwu+j7l2J4CzHEUcdxA6WXOVXKcTleX08ZWzjEUsW61fM4ZlWniMHmcK9ahUl\
HCUp4KnioYP2GHf6pluA8CPErw+xOA4orYKjPh/OcFThnmE4cyqtlcML7PB4vDYDA4aGBqYHA5M6+Nx\
Ea9DA0aGGw1eWZ4vMq/9pY3NMXjv9UHxDr+hT6FrltDrWkzXE2k6nBFbxajZyTSzSWc8ccMcSTFnlZy\
FCgEknAGa1v8AhJvDn/QwaJ/4NbD/AOSKPE3/ACLniD/sCar/AOkFxW3X8M63eq+7/g+v9b/42nG+H/\
EGg2+g6Jb3Gt6RBPBpGmwzQzalZxSwyxWcKSRSxvMDHIrqwZSAQQQRmjRPEGgwWcyTa3pELtq/iCZUl\
1KzjYxXGvalcW8oV5gTG8Esbo3RkkVlJBBrX8M/8i54f/7Amlf+kFvR4f8A+PC4/wCw34m/9SPVamN/\
ct/Lp6afe/PT0Ax4PEOgDX9TmOuaOIZNH0OKOU6nZCN5Ib3xC8saSGfDOqzwlgDlRMpOAwz+YH7T+ua\
JL/wVg/4JS3MWsaXJb2vwl/4KRfap49QtHhtvP8H/ALM8cPnyrMVh3uCq7iNxGBk1+q9v/wAjHqv/AG\
BPD/8A6X+Jq/Lz9qP/AJSzf8Env+yS/wDBSf8A9Qz9metaXNd3a2n08peZ4HEv/Iuw3/Ywyn/1aYM/Q\
vxva+A/Gkfh3TdevNI1XTbTxA2pSxJrn2Zbd4/D3iCzhuZp9Pv43jj8y9WMbmCF7hVILFa/Gb/gp3/w\
Sj+C37S/hO4+K/wF0/wdov7SHhuCyjbT7jWrGbSvjJoNrLbW6eGtev8AXNSePQ/FdpZK39k6xJLFa+T\
G2l6266ebLU9A/dHVf+P/AMM/9hu4/wDUc8QUeIP+PC3/AOw34Z/9SPSq8niDK6HE+Q4vhrN6lStlFe\
XtPZRqTiqVZR93EUVdxp1oXfLPld05Rmp05zhL9n8MvFnjrwj4oyjivgvOZ4PGZTU5nhqvNWwGLpSa9\
thcbg5SVLEYaulapFqM4yUK1CpRxFKjWp/54Xwp+Mtp+zfaePPAPiH9mj9m74kam2rXVpdaX+0B8Jbv\
VvFnw98Q6St7pOuaXpc2la9o2o6XcteRwpd6fqLXUVrd6TutbazuJ9RN53XxC/b78K2miaPdWf7BH/B\
OFLi3+IvwjmXzfgJ4l1CF0j+K3gxp4biy1L4rTwXNtJAJElWSJh5cjEFWAdf9APxN/wAi54g/7Amq/w\
DpBcVg/EXwnf8AjXwudF0rV7TQtTt/EXgnxNpuqahpE2vWEF/4I8a+HvGlnDe6Rbaxp8l7aT3Hh+OCV\
Y723cJcs6yBlAP5ll/BXilkeWUMoy7xvzieSZfT9nTy/lqKlPDq9sHeeYcsaUo3pJWVOEJWUVBKJ/a3\
if8AT28MuN+HuOcRjPocYLNuJ+IcqxlG2H4vxGCjiMXPA1KEPZ0Y5TQwtGVafIm6k4Q5n7SvWcnUqv8\
Az8of21vjDDr3jHwP8DvhT+yl8FfAXxa+GL2Pjz4S/Bf9mb4CfDzwbrUPhjU/AGn2ep6hqsugR65q/i\
Kzu7rUdTsLm+8Qz3Wmanq9xc6RLp4WBLf8XPiH4ovdB8Q3unT6VoHhPRtT+Ll94P8AF2laJqNhP4cOk\
20Xh+z1s61Ne6tqs6a7cxWWqJLcXpW2Nnds8Ud0ixSWP+nV4z/ZbsfjLrPhHUfif4e/Zk8b+Ir74N67\
4Nt/FviH9m7U73xhpng6W68LzyaFpnjEfGhNX0fy77WLi5s5tPv7JrG6nuLq2VLqZZov8z/4v+Dtb8d\
eA/Evj/xpa/CrwhGuoaj4q1pPAekeKrKe41y61CH7dqsY1z4g2una34jvSxg8y9tXnkN+0FmouJU3+7\
xDi8Lw74a8EZbxT4iZzjuMpZtiYxp49UJ0KuBx0XhubKJ4PDYjH4epQdDBUsxwuMzRYOrRpYFYLDVXh\
oQoe/4beMmVfSF4H8YMD4FfR1reB+Y+Fjw+cY7A0ZcPwy3FQhk2A9tVxOaYKr7SriZ4PAVKNevi6OHr\
YmnVoudeoqOJlQ/1jvEOgaFBoWuXMOi6TDcQ6Tqc8VxFp1nHNFNHZzyRzRypCGSVXAYMCCCMg5rW/wC\
EZ8Of9C/on/gqsP8A5HrH8Q6Zex6Brkj+IdYnVNH1N2hlg0ARzKtlOTFIYdDRwjAEHY6tgnaynBGx/Z\
V//wBDNrf/AID+HP8A5n6/QtG3eHbt/n/VvQ/zCMjw/wCH9BuNB0S4uNE0ieefSNNmmmm02zllmlls4\
XkllkeEmSRnZizEkkkknNGieH9Bns5nm0TSJnXV/EEKvLptnIwit9e1K3t4gzwkiNIIo0ReipGqqAAB\
SeHtMvZNA0ORPEOsQK+j6Y6wxQaAY4VaygIijM2hu5RQQBvdmwPmZjkk0PTL17Kcr4h1iEDWPEKFI4N\
AKlo9f1ON5SZdDY73ZS7YIUNIQiom1FmOvJeN7q/TV6a7/nqAQeHtAOv6nCdD0cwx6PocscR0yyMaST\
XviFJZEjMGFdlghDEDLCFQchRj8wP2n9D0SL/grB/wSltotH0uO3uvhL/wUi+1QR6faJDc+R4P/Znkh\
8+JYQs2xyWXcDtJyMGv0/g0y9Ov6nGPEOsBl0fQ3Mwg0DzJFe98QhYnB0MoEQxuV2orEztvZgECfmB+\
0/p92n/BWD/glLE2uapK83wl/wCCkXl3MkOiCa18vwf+zOz+QsWjrG28Ha3mxyYA+TY2WrWild+5bSf\
b+V+Z4HEv/Iuw3/Ywyn/1aYM/UDUvD+gxXnh9I9E0iNLjV5obhE02zRZ4l0HW7hYplWHEsYnghcK2Rv\
hVsZUEGt+H9Bgs4Xh0TSIXbV/D8LPFptnGxiuNe023uIiyQgmN4JZEdejJIysCCRSanpl6t74eB8Q6x\
IZNYnRHeDQA0DDQNckMsQj0NQXKoyHeHXbMxChwjqa5pl6llAW8Q6xMDrHh5AkkGgBQ0mv6ZGkoMWhq\
d6MwdckqWjAdXTcjZfz+5tttpovP56Hvi+IPD+g2+g63cW+iaRBPBpGpTQzQ6bZxSwyxWczxyxSJCDH\
IrqpVgQQQCDmtf/hGfDn/AEL+if8AgqsP/kesfxDpl7HoGuSP4h1idU0fU3aGWDQBHMq2U5MUhh0NHC\
MAQdjq2CdrKcEbH9lX/wD0M2t/+A/hz/5n6dlf+H27f5/1b0A8/wBJ8P6DNq3gOabRNIllm+H+uyzSy\
6bZSSSyvc+AGeSR3hJeQszEsSSSxJPNf53Vh+zn8eNZ+Fng/wAF+Pf2EPid4Q8UaVYm68bWtx+z9+0L\
NrOvX2t2Wga3Z2Hizw/43TU9P04afPE09jHYadp0mdYle9a8KWZtf9EXSdNvZNW8BuniDV4Vf4f666w\
xQ6CY4Va58AERRmbRHcxqCAC7O2FGWJyT8m/t+/Dr4k/EH9mH4keFfhlo6fEfxhcfGn9l68g8D+IfC3\
w38Y6D4r0nQP2gPgB4k8WWmv8Ag7x1408GaR4v08eD9N1ozaRd+KvD9tqcNn9ha+iluC0nx3iFwNgeN\
cryOliqmKpVcuo1alFYP2SxE6jrynGFOdSjXlCUp0YJOjBVXflUnGUoT/fvoefSEzHwA8RvEHG4Xh/C\
8T4HjLGYTLMVhsdXxMMFGlVy3LKc61fCUq1HD472dKtWUaOMbox9pKSlTk/aR+3PEMOujQtcabUdJkt\
xpOpmWKLRbyGZ4RZzmSOO4fX3WKUpkBzG4UncUYDadb7P4j/6Cuif+E/f/wDzTVk+IZtdOha4s2naTH\
bnSdTEssWtXk0yQmznEkkdu+gIssoTJCGRAxG0uoO4a32jxH/0CtE/8KC//wDmZr7LS73/AB/q34b+Z\
+AmR4fh15tB0RrfUtIigOkaaYY5tEvJ5Y4jZwmNJZk8QRiaQJtDMI0DEEhFB2jm9Y0Xx/rvgPxjo3gv\
x1pXgPxRq9j480rw14zbwXH4pl8I+Jr661yz03xZHoGqeIY7TXVsdZlivY7C6HkTrbLa3DyIzyN0nh+\
bXl0HRFt9N0iWAaRpohkm1u8glkiFnCI3lhTw/IIZCm0sokcKSQHYDcTRJteFnMIdN0iRP7X8QFml1u\
8hYStr2pNcIETw+4MazmRUbcC6IrskZYxrlKEakHTm5KNSLi3GUoS1SXuyg1KPlKDVnZpppM2w2IqYT\
E4fFUownVw04VIqrSp1qblCSklUo1oVKNWDaSnSqwnTqRvGcJRbTzdBtPGsNyINe8QeFtS8Rw+FvC0e\
varpHg/VtE0TUtSSTXEvLvSNAvPHGoT6JYyXyXkkVvNqWoSQwzxQvczvC9xP/K3/AMHOm4eJ/wBhzTt\
d8R+C9Pk1Xwr+0mmmy+INX0LwFpNw2ifGn9gjxXq9nJrPjTxTFYtdHw74f1eeKJ7mJ5PsLxxLPK6Rn+\
rWCfX/AO39TI0zRzMdH0MSRnXL0RrGL3xCYnSUeHiXdmMwZSihRGpDOXIRZpte/t7TWbTdIE40jWxHG\
NbvDE8RvPD5md5j4fBjkV1twqiNg4lcl0KKsnFmWDqY3Ksfl+GrrDVcZRq0FUqQqVowVWLpuTh7WlKb\
UZNpe1i3KzbeqemHxlbDZvlGc0lD61k2ZZfmdOLglSlWy/H4fMKdOVOn7NRozqYeMJwp8nLTk1Dlsrf\
yGf8ABKf9u/8AYK/Z3+L/AO1l4w8QeN/gB+x/8P8A4oN+ztJ8N/AMnxu0P45RWa+BPDXxx0zxdar4t8\
O+Kb7U762g1fxdaXYj1Rbco3jeOOwnuorC8C/tnqf/AAWg/wCCZVzbRRj9vT9necrqGk3GyL+37dlFr\
qtldGYyTXTBo4xCZHQANKkTRIyO6uv6galNrxvPD5k03SEddXmNuqa3eSLLL/YOtqyTO3h9TBH5BmYM\
qyEvGqbAHMiGtza8bOETabpEaf2v4fKtFrd5MxlXXtNa3Qo/h9AI2nEau24lEdnVJCojb5PJOHeKshy\
yjleE4iy6ph8PKrKLnk1eLbq1Z1pe7RzejRhFTqNQhClCEIKMYxUEkfWce8b4zxD4qzHi7OcHHDZjmc\
MLTnCjWxNSCjg8Hh8DSbrY6rjcbXqyo4anKvicXi8RicRXlUr1606lSUn+X+rf8FoP+CZV1pWp2o/b0\
/Z3uTc6fe24t4f7ftZZzNbSxiGK5nunS3kcttV3RlQsGZWAIOh/w+o/4Jk/9H9fs5/9+PEf/wAnV+mH\
iCbXm0HW1uNN0iKA6RqQmkh1u8nljiNnMJHihfw/GJpAm4qpkQMQAXUHcNf7R4j/AOgVon/hQX//AMz\
Net9U4zv/AMj/ACz/AMNGM/8An5/WvmfH82H/AOfU/wDwZH/5Wfjs3/Ban/gmTompeDZ7n9uv4FLbWf\
hDW9KmFlo/jTX5LO7ln8GvBaXT6Gsm6Qx6fd4l2JG5tmK4yBWTrf8AwW+/4JfXdrex2v7cfweaWbxl4\
L1Y7vB/xLCz2ukax4Rur29iDaYv2eKK00u4zC5eWRrNzGf30SL+w/h6fXxoGhiHTNHkhGj6YIpJdcvY\
ZHjFlAI3kiTw84icrglQ7hSSAzAZK6bNrwvPEBj03SHdtXhNwr63eRrFL/YOiKqQuvh9jPH5AhYsyxk\
PIybCEEj+hh3xZT+oVJ5vl86uCtytZZi4xdqkqquv7Xk95WfLJXS0tqfP0MDmmX5rmGY5Vj8PSp4/E0\
sV7PEYWpXlGpTw2Gw9vaU8ZhlKElhYyt7NSTlJczSVv//Z'
	$begin 'DesignInfo'
		DesignName='main'
		Notes=''
		Factory='HFSS 3D Layout Design'
		IsSolved=false
		'Nominal Setups'[0:]
		'Nominal Setup Types'[0:]
		'Optimetrics Setups'[0:]
		'Optimetrics Experiment Types'[0:]
		Image64='/9j/4AAQSkZJRgABAQAAAQABAAD/2wBDAAEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQEBAQE\
BAQICAQECAQEBAgICAgICAgICAQICAgICAgICAgL/2wBDAQEBAQEBAQEBAQECAQEBAgICAgICAgICAg\
ICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgICAgL/wAARCADIAMgDASIAAhEBAxEB/\
8QAHwAAAQUBAQEBAQEAAAAAAAAAAAECAwQFBgcICQoL/8QAtRAAAgEDAwIEAwUFBAQAAAF9AQIDAAQR\
BRIhMUEGE1FhByJxFDKBkaEII0KxwRVS0fAkM2JyggkKFhcYGRolJicoKSo0NTY3ODk6Q0RFRkdISUp\
TVFVWV1hZWmNkZWZnaGlqc3R1dnd4eXqDhIWGh4iJipKTlJWWl5iZmqKjpKWmp6ipqrKztLW2t7i5us\
LDxMXGx8jJytLT1NXW19jZ2uHi4+Tl5ufo6erx8vP09fb3+Pn6/8QAHwEAAwEBAQEBAQEBAQAAAAAAA\
AECAwQFBgcICQoL/8QAtREAAgECBAQDBAcFBAQAAQJ3AAECAxEEBSExBhJBUQdhcRMiMoEIFEKRobHB\
CSMzUvAVYnLRChYkNOEl8RcYGRomJygpKjU2Nzg5OkNERUZHSElKU1RVVldYWVpjZGVmZ2hpanN0dXZ\
3eHl6goOEhYaHiImKkpOUlZaXmJmaoqOkpaanqKmqsrO0tba3uLm6wsPExcbHyMnK0tPU1dbX2Nna4u\
Pk5ebn6Onq8vP09fb3+Pn6/9oADAMBAAIRAxEAPwD+w698I6Av9oZ8KaOu3+1858LWUe3Z/wALCzn/A\
ItzD5e37PJn/UbPsp/49fsx/sPL8U+FtFttF8TzweGNLt57fS/E8sM0Xhi0glglgtPiQ6SRunw3iMEi\
PbMQQITGbMkC2Nt/xI+svbLb9v8A9A2bP7W/5hPl7PL/AOE//wCpAh8rb9k/6YeX9h/5dfsv/Eix/F1\
lt0DxWP7P27dH8UjH9kbNvl2XxG4x/wAK9j8vb9k6bYtn2LpbfZcaH9lFtSi07NNHOFt4R0A312o8Ka\
OxHiXUYyv/AAi1k5Vl8ReEIzCY/wDhXMmxg0qJ5XkxbTOIv7Pg84WGqFl4R0Bv7Px4U0dt39kYx4Wsp\
N2//hXuMf8AFuZvM3faI8f6/f8Aah/x9faR/bmxbWW69u1+wbtviPUIdn9k79uzxB4Sh+z+X/wgEmzb\
9o2eT5MWz7V5X9nwef8AYNULKy3fYP8AQN+/+yf+YT5m/wAz/hAP+pAm83d9r/6b+Z9u/wCXr7V/xPV\
d9wOT0Lwtos13eJJ4Y0uVItU0KK3V/DFpKqRSaL8JZ/LhDfDeUGNp753wv2gSPfls3RuiNbdZ+E/D50\
eFx4X0ZgdNuW8weG7JwQLXx6S/n/8ACEy7gBA53/anx9lJ+0R/ZzJoul4fst17qX/Ev3eZrGhH/kEb/\
M8zQPhGM5/4V7L5277X1zc7/tuM3X2rbrc9na7tIhk+yb86bcv5v9neZnba+O28zz/+EPl3Y+yZ3/an\
x9i3faI/s3maJbb5W76rl/J/5L7kBia74W0WG7s0j8MaXEkuqa7FcKnhi0iV4o9F+LU/lzBfhvEBGs9\
ij4b7OI3sA2bU2oGialz4R0AX1op8KaOpPiXT4wv/AAi1khZm8ReL4xD5f/CuY97FonTyvJl3GAxf2f\
P5JsNLPEFltvdN/wCJft8vWNdP/II2eX5egfFwZz/wr2Lydv2Trm22fYsZtfsu3RNi5stt7aL9g27vE\
enw7P7J2bt/iDxbD9n8v/hAI9+77Ps8nyZd/wBl8r+z5/I+waXF3pq9NvIDHsvCOgN/Z+PCmjtu/sjG\
PC1lJu3/APCvcY/4tzN5m77RHj/X7/tQ/wCPr7SP7cy/C3hbRbnRfDE8/hjS7ie40vwxLNNL4YtJ5Z5\
Z7T4bu8kjv8N5TPI73KkkiYyG8BIuTc/8TzrLKy3fYP8AQN+/+yf+YT5m/wAz/hAP+pAm83d9r/6b+Z\
9u/wCXr7V/xPcfwjZbtA8KD+z927R/Cwx/ZG/d5ll8OeMf8K9k8zd9r6bZd/23pc/asa4XdrXdv8tgM\
2Lwn4fMd8f+EX0Y7dN0lif+EbsjtD+BdZnDk/8ACEt5YZEMu/dDvEZuPtFyE/tm0bceFtF/trX4G8Ma\
WIIdL81IW8MWiRQyvd/F5LiREPw3hEMhSwjDkGEqNPUMLQWg/sTbitcx3x+yZ2abpT5/s7ds8zwRrF1\
5mf8AhD28vd5fnb90O/yvtP2i58v+2bSCay26/wCIj/Z+zbo8Iz/ZHl7PKvfjDxn/AIV7D5ez7J03Q+\
X9i6Wf2bOiW21ezt7q/wDbQC98I6Av9oZ8KaOu3+1858LWUe3Z/wALCzn/AItzD5e37PJn/UbPsp/49\
fsx/sPLvvC2ixPMYPDGlxyf8JxaWzeV4YtN4SXx54BtLi1ZE+G8pVGiumieHyYgFuzC1hbif7FqfWXt\
lt+3/wCgbNn9rf8AMJ8vZ5f/AAn/AP1IEPlbfsn/AEw8v7D/AMuv2X/iRY+p2W4yJ/Z+/b4702HZ/ZH\
mbfL+IHw/i8jyv+FezeXt+0bPK8iLZ9p8r7Bbef8AYtTmLalFp2aaALLwjoDf2fjwpo7bv7IxjwtZSb\
t//CvcY/4tzN5m77RHj/X7/tQ/4+vtI/tzNvPCfh8aPM58L6MoGm2zeYfDdkgANr4CIfz/APhCYtoIn\
Q7/ALUmftQP2iT7QJNa6qyst32D/QN+/wDsn/mE+Zv8z/hAP+pAm83d9r/6b+Z9u/5evtX/ABPc68td\
ukTSfZNmNNtn83+zvLxutfAjeZ5//CHxbc/a87/tSZ+27vtEn2nzNbIfFH1QGJa+FtFltNVefwxpbum\
qeM4g0vhi0DRxWutfFKCGMF/hvAYo4oLMIo/ciJLHaDbC1zoepe+EdAX+0M+FNHXb/a+c+FrKPbs/4W\
FnP/FuYfL2/Z5M/wCo2fZT/wAev2Y/2GafZbLLVv8AiX7NmseOD/yCPK2bNf8Aikc4/wCFeweVt+ydc\
Q7PsWc2/wBl3aHsXtlt+3/6Bs2f2t/zCfL2eX/wn/8A1IEPlbfsn/TDy/sP/Lr9l/4kSbbbbbbYHJ6z\
4W0WLWfDEUfhjS4lufHFpbTxJ4YtI1uENx8RnW1liX4bp5yG5s48QmGQM9mEFhO1uNP0zUsvCOgN/Z+\
PCmjtu/sjGPC1lJu3/wDCvcY/4tzN5m77RHj/AF+/7UP+Pr7SP7cNcssa14TX+z8Z8d20Oz+yNud5+J\
MHkeX/AMK9Tdu+z+X5XlPv+zeT9guPI/s/TNiyst32D/QN+/8Asn/mE+Zv8z/hAP8AqQJvN3fa/wDpv\
5n27/l6+1f8T0u9NXpt5AY9l4R0Bv7Px4U0dt39kYx4WspN2/8A4V7jH/FuZvM3faI8f6/f9qH/AB9f\
aR/bnM+HvDGiXGg208/hvSp55PDPhqeeabw7aSyvJP8ADvVLp55pH8Dkh32vMZGMBk2G5M9zsOsWnfW\
Vlu+wf6Bv3/2T/wAwnzN/mf8ACAf9SBN5u77X/wBN/M+3f8vX2r/ie8t4Ztf+KcsP9D+54V8Lv/yDf9\
Xv+HepXW//AJE39zu8rzt3+j7/ACvtPn3Hl/2xaVFvlmr6WT+aaA0b3wjoC/2hnwpo67f7XznwtZR7d\
n/Cws5/4tzD5e37PJn/AFGz7Kf+PX7Mf7Dy7jwtov8AbWvwN4Y0sQQ6X5qQt4YtEihle7+LyXEiIfhv\
CIZClhGHIMJUaeoYWgtB/YnWXtlt+3/6Bs2f2t/zCfL2eX/wn/8A1IEPlbfsn/TDy/sP/Lr9l/4kWPN\
Zbdf8RH+z9m3R4Rn+yPL2eVe/GHjP/CvYfL2fZOm6Hy/sXSz+zZ0RJu0ten6r/JAFl4R0Bv7Px4U0dt\
39kYx4WspN2/8A4V7jH/FuZvM3faI8f6/f9qH/AB9faR/bhWxZWW77B/oG/f8A2T/zCfM3+Z/wgH/Ug\
Tebu+1/9N/M+3f8vX2r/ielc9aUly2k1vs/QqO/9d0ctdWetj7ZjxD4VbH9pbdng7wqm7H/AAmWzZ9l\
8dN5e7y4Nvk7tn2qD7Nv+z6L9pyvE9pqy6J4kM2veGZoF0rxEZY4PCXhC2kmhW08cFkglj8aypbu6Rw\
iNkSVYzdwGBZRb6MLrvr293fb/wDT9+/+1v8AmLeZv8z/AIT/AP6n+bzd32v/AKb+Z9u/5evtX/E9x/\
F17u0DxWf7Q3btH8UnP9r793mWXxG5z/wsKTzN32vrul3/AG3rc/as651Rm7rRb/yx/wAiTOgs9bN3c\
A+IfCqqNcvVDN4O8KsjRjWvDarMqT+OhEkBjeV1jjZrFUgljhlayl1KWEtbPWz9jz4h8Krn+zd2/wAH\
eFX25/4Q3fv+1eOl8zb5k+7ztu/7LP8Aadn2jWvs3U217tvbtvt+3d4j1Cbf/a2zdv8AEHhKb7R5n/C\
fx7932ff53nS7/svm/wBoT+R9v0ssr3b9g/0/Zs/sn/mLeXs8v/hAP+p/h8rb9k/6YeX9h/5dfsv/AB\
Ilzvsv/AY/5AcDotpqzXeohNe8MxuNV0gXJl8JeEJlMzaJ8NCXVZ/GsZVFglKutySztZXL3DRpdauln\
PbWmunTYide8Mq/2GcmNvCWhvKGFv4vIQzXXjVbkyEpAAzIJwbqEohkg0cXG/4fvdt7qX/Ew2+XrGhD\
/kL7PL8vQPhGcY/4WFF5O37J0xbbPsWcWv2Xdok9ndbdIhj+17Mabcp5X9o+Xjda+O18vyP+Ewi25+1\
42fZUz9t2/Z5PtPl63Tk7N2WnL0Xb08vz7sDktatNWW704Pr3hmRzquri2MXhLwhComXRPiWQ7LB41k\
LI0EQVFtiGRr22e3aRLXSEvNWez1sXduB4h8Ksp1yyUsvg7wqqLGda8SK0zJB46MTwCNInaORlsWSeK\
OaVbKLTZZtHxBe7r3Tf+Jhu8zWNdH/IX3+Z5mgfFw4x/wALCl87d9r6Yud/23OLr7Vu1vYub3de2jfb\
923xHp82/wDtbft2eIPFs32jzP8AhP5Nm37Rv87zotn2rzf7Qg8/7fqk88uy0/ux/wAgOWtbPWz9jz4\
h8Krn+zd2/wAHeFX25/4Q3fv+1eOl8zb5k+7ztu/7LP8Aadn2jWvs2V4YtNWbRPDZh17wzDA2leHTFH\
P4S8IXMkMLWngcqk8snjWJLh0SSYSM6RLIbSczrELjWRa99ZXu37B/p+zZ/ZP/ADFvL2eX/wAIB/1P8\
Plbfsn/AEw8v7D/AMuv2X/iRY/hG926B4UP9obduj+Fjn+19m3y7L4c85/4WFH5e37J13RbPsXW2+y5\
0M55dl/4DH/IDAjtNd2Xede8MjFjp5UHwloZLMfCepuyIZPGoZJFmCRM0Iad5pEnuETVktbeT8LP29P\
26f2+fhR/wUI8K/sc/sgaD+y34x1Dxz+zZ4U+K8Z+Kfwd8QeIdcvtav8A4g/tY6Vqthpl74A/aE0W20\
zS7fwr8LFu4kaGeXzr8NbzG3tdJZ/35iusR3w+1436bpSY/tHbv8vwRrFr5eP+EwXzNvmeTs2zbPN+z\
fZ7bzP7Gu/5W/8Agqfd7/8Agrt4tf7Zvz/wRs+Py7/7T83Pn/Dz/grAdnm/8JrPu8z7Tnb57+d9qz5W\
o+fv1X47j7McdlvD6rYDG1Mvr18blWHdahHDutCli8xwmGruk8Th8VQjUdGrNU5VcPWhCTUnSmlyv3e\
HamFoY7F4vF5Vhs7pYDL81xMcLi3i1hqlbDZZjK9D231DF4HFunTr06dRwo4ug58nJKfJKUX9Ay/H7/\
g4Tbzs/BP9gr5/tOdnwB+Kcf8ArP7a3eX5P7W37r/j7l2eX/q82/lf8ethjPv/AI+f8HBRTN18GP2C4\
ozr+n3CsfgD8UnQ3g8R6Bc2kaxy/tYuiWr31raKIUUW6RPNFG0cE926/NX/AATZ/wCCZH/BMX9oL/gn\
zB8afiT4G8AWHi3RfD/xs/4T7xt4jufg5r2t/Bm+1n4X3fhLxjq+q3t14W021tNLg0TwnaeMfDVn4ht\
PEMnhNvHQ1LT9UuNVmW91T3j9i3xwnwD/AOCZ3/BWTxr+zl4Mvf2cX+CPxH+IPiL4J6TcP8PNS1ayv/\
hf/wAE/f2EL/wD8Zb+DwhLbeFfF+teLb/wxpnju5vtO0fUtD1258Wyajb3PiGylXVIPM4F4ezfjnPuD\
8gwnH+fYPE8bSw0cHOWK4aqQj9Zq0KMJV3T4MvThGpXhz2UqnLzclOc4VIU/wBg8RuGp8Af67U/9VOF\
8xr8A5zLJMwVXJ+L8HH60ljJJ4dy8Sa868HHBVXzRpckfddScadfCzxPWxfH7/g4TXycfBP9gr5Ps2N\
/wB+Kcn+r/sXb5nnftbfvf+PSLf5n+sxceb/x9X+YJfj3/wAHCTWrRn4J/sHbTBGh2fAb4txzYWPR1G\
2eH9rfzllxaxZcfvCRcM3zXN9n9YvCP7C3wk0Lw/4U0bUvjN+2z4s1HRtH8LaZf+LPEX/BRv8AbdsvE\
HiS90yy+HNrdeItctvCf7XejaVZaxdz6dJc3SaZpmkafDPG62djpVtaR2/h6e8/Yl+CzaRNH/wsD9sF\
86bbJ5X/AA8c/b8kzttfAi+X5H/DY8u7H2TGz7K+PsW37PH9m8vRP06fAPAUK0qcPHbj+tGEnFTjkHB\
SjNJ2U4qdCE1GW65owla3NGLul+NPi7MnHTw24Li2v+fXGjs//E2advuPyNsfj5/wcFC2uxa/Bj9guW\
J9Q8QNIy/AH4pRkXM+q+J3vo4/I/axTygl5e3iR+WDsC23lO/2Wwc6Evx+/wCDhNvOz8E/2Cvn+052f\
AH4px/6z+2t3l+T+1t+6/4+5dnl/wCrzb+V/wAethj9XrP9i34MT2mqs3xE/a+ctqvjSMbP+Cj/AO3w\
VdRrnxQiXKx/tsTCZ3W4G5j57TNfFn+1Ndt/bv8ALt8MP+C1H7LHif4i6v4X+L37O/8AwUP8DeDl8Ea\
rrqeLPhh/wVe/b++MGuJ4vvNU1+Cw8H6v4R8WftF+DrewtpdF8Qajfy3g1m9vI45LUHSL2HUNRuZfAz\
fJvCrIXhlnHj/x9gFilNwlPh/gtwtT5OfmqLDuELe0jb2kouV/dvaVvv8Agfh3xN8SXmFPgXwV4P4lx\
GVyw8KtGg+LfrPNivbex9lhqnHdOviE/q9X2ksPSqxo2i6zpqpT5/0b1H4+f8HBT32iSXHwY/YLSaLX\
1uLJU+APxSSOa8W38TOY5Y4/2sWR7UW11fO0LFLd0jgikY28FrG+hF8fv+DhNfJx8E/2Cvk+zY3/AAB\
+Kcn+r/sXb5nnftbfvf8Aj0i3+Z/rMXHm/wDH1f5+KvgT/wAFcf8AgnN+0CuiX+u+P/2jf2a9cXxZqO\
p2fhf9pj/gqx/wVG8F3eoaTofgnxF8SLbxLD4y0D4na94d0rTL+z168g0pZfEFt4h1G+tY7SxsmudZt\
bjWPrz4Lfte/sE/Hz44/C79nD4JftHeLviV8ZPip4d0jxT4B8KeFv8Agrr/AMFgLu01LTB8PtN+KLW+\
reLob6PRPBviCy8GeCLibVtI1XUdN1XQ7yxm0nUrLTtXsrSxsd6PDvhniIe1o+O/iFVpc/s+aPDnBri\
5+4uVP6tbmvOKst+aP8x+S4vxLx+X1nh8b4L5Tha6p+1cKnCvitCSpWk/aWfEKfs7U5tyeicJ3fuyS2\
Yvj9/wcJr5OPgn+wV8n2bG/wCAPxTk/wBX/Yu3zPO/a2/e/wDHpFv8z/WYuPN/4+r/ADxU37Vv/BdH4\
f6P4N1Xx38K/wBi3SvAOreLPgv8O7zXPDn7M3xT8WeIbOL4n+KvDPwm8P3+k+Hbz9s3SIdUv11Lxlpr\
NG9/piTTFbm7u7O4iSaP9PbX9kbxIn2Ty9P+K37v+zvK3/8ABaD/AIKbW/8Aqf8AhD/I8zb8Qo/s3/I\
P0vfjy/I23GPJ/syP+zfh39r/APZb/aA8OfAn4ceOPgD4i8Q+FPir4S/aD/Yc13wfB8WP+Ckv7bfx7+\
C3jTWH+N3wz8K+H/CHxj+EPxSfXbLXvh5NP4itry8bRxZa5oWoaJYPo+pWXkyaVqOtfhLgeGGxk8H44\
8c08bSoVqlF5jw9wxQy91qcHOlDG18JgMRiKGFqVFGFatSo1KlKm5VIx91uPXwv4m4TP+J+G8jq+E+V\
VaOc5hg8JOGD4d8SIYucMTiKdCUcNPHcTU8HDEWn+5liqkMMqnK8RKNLna+iYviR/wAFOb++XTofEPw\
fgutQbVo7H+1P+CaeieHre6lt7HxhqTQRXuo/8FqoYbe4ayhLxxxyFwZFS0WV9P0tbjbl1H/gqeNY1l\
08U/s+PcHTYlkRP2B/hmhMMd18STbOiWv/AAXAPkiSRZQhhlm2/aYBbRj7Jozaha+H37ZXxJ/an0DVf\
DeufBf4f/Cr4w/CH42+GPAX7Qf7O3jr4/eJdV8f/DDxxfnxnqujWmq28Pw7m0/xx8K/EWkX+o6l4Y8Z\
6NJrGheJNHlju7GSS+l1i1j4bR/29/hJ4r1LxDq3gP4C6H8UfDS3GreG7Xx38GPgv+3Z8afhdrt94U8\
W/Efwrrt14G+Knwu/Yh1vw98QNCg8QpqltDqukahqGlXjaAj21/fxyXjT/TYnwY46hicXgaD4zr4/LJ\
U4YulhMkwmZwouvGVbB1frWEyWOHnh8fhovE4GtTdShi8PH6zhq1ajOMl+H4Pxdrf2zxBk1bJ45gsnn\
Q5MRHLOJcFzxrUlKVN4eOXZm3KlVjNOr7eEakZxjGkuSVSp6Da6n/wVVP2TPib9nxM/2dnf+wL8M5Nm\
7/hD8+Z9q/4Ljr5m3zJN/nbN/wBiuPtPl/adZ+yFY0X7bHhWPyv+MQvGT+X9nzu/ZI/4KYLv8j+yM7/\
L/wCCey7d/wDZjbtmzb9vl8vy/LtPshXLLwT8Sp25cHx87duE6ct7d8pVv67HtR8Uofb4fcdrWwvE77\
f9U6j9Wb3xLpv/ABMN/jbwJJ/yF/M8nxzqc/m/8lC87yPO1lvtG/8A4mHleZu87+1LDzd/9oX/ANoy/\
FOv2dxovieCLxl4HubifS/E8KRW3jfV7mS5mktPiQhjtVOss108rm+EIbc0x1Ww8zedQv8A7R1l7Zbf\
t/8AoGzZ/a3/ADCfL2eX/wAJ/wD9SBD5W37J/wBMPL+w/wDLr9l/4kWP4ustugeKx/Z+3bo/ikY/sjZ\
t8uy+I3GP+Fex+Xt+ydNsWz7F0tvsuND8uNuaN1pdf1sfpwW3iXTft13t8beBEf8A4SXUd8knjnU4oX\
uf+Ei8IeZdxTx6yHl09rj7JLHcuxuZILG6uJJGuLS0khLLxLpv/Ev2eNvAkf8AyCPL87xzqcHlf8k98\
nz/ACdZX7Ps/wCJf5vl7fJ/su/8rZ/Z9h9n2Lay3Xt2v2Ddt8R6hDs/snft2eIPCUP2fy/+EAk2bftG\
zyfJi2favK/s+Dz/ALBqhZWW77B/oG/f/ZP/ADCfM3+Z/wAIB/1IE3m7vtf/AE38z7d/y9fav+J6tAO\
T0LX7OO7vHbxl4HgS41TQprNrjxvq9uDCNF+EsEcjlNZURJHcQ2yymHasLaPqAi2Np1l9ndZ+JdJ/se\
HZ4w8GRw/2bc4gl8YXcN2sf2Xx7uhezh1VYUuCv29VjCCNm1KyVlK398J9Lw/Zbr3Uv+Jfu8zWNCP/A\
CCN/meZoHwjGc/8K9l87d9r65ud/wBtxm6+1bdbns7XdpEMn2TfnTbl/N/s7zM7bXx23mef/wAIfLux\
9kzv+1Pj7Fu+0R/ZvM0S3blfb3fyf/B/DtqGJruv2cl3ZuvjLwPOlvqmuzXjW/jfV7gCE6L8WoJJEL6\
ywlSS4muViM25Zm1jTxLvbUb37RqXPiXTft1pu8beBHf/AISXT9kkfjnU5YUuf+Ei8X+XdyzyayXi09\
bj7XLJcowuY4L61uI5FuLu7kmPEFltvdN/4l+3y9Y10/8AII2eX5egfFwZz/wr2Lydv2Trm22fYsZtf\
su3RNi5stt7aL9g27vEenw7P7J2bt/iDxbD9n8v/hAI9+77Ps8nyZd/2Xyv7Pn8j7BpcaaaPz1/4Gn4\
gY9l4l03/iX7PG3gSP8A5BHl+d451ODyv+Se+T5/k6yv2fZ/xL/N8vb5P9l3/lbP7PsPs+X4W1+zt9F\
8MQS+MvA9tcQaX4YheK58b6vbSW00dp8N0Ed0o1lWtXicWImC7WhOlX/l7Dp9h9n6yyst32D/AEDfv/\
sn/mE+Zv8AM/4QD/qQJvN3fa/+m/mfbv8Al6+1f8T3H8I2W7QPCg/s/du0fwsMf2Rv3eZZfDnjH/CvZ\
PM3fa+m2Xf9t6XP2rGuGltnf1+/p/XmBmxeJdJ8u+x4w8GKP7N0neG8YXaNJH/wgus+VDCq6qBPcJY+\
dbSxuGjivbiGxiVLKaaB/wCb/wDbP0Lwd8T/APgvR8PfAHjbx74c0rwT8Rf+Cafi74ceKvE+jeOmtjp\
mi+OYP+Cn3hLWX03X9dubq3tNdki164/s0XUdxb3E+raaby2uvt13Hc/0sxWuY74/ZM7NN0p8/wBnbt\
nmeCNYuvMz/wAIe3l7vL87fuh3+V9p+0XPl/2zafz6fHK12f8AByn+zRH9k8v/AIwEun8r+zvJ/wCPf\
Wf+ClC+Z5H/AAh9v/qvIxv+yjyPs+37Rpnk+XpvxvHkKdTKMtp1o89KeccPqSTteP8AbWX3V2na6ur2\
e97dD3uHXT+v4qNan7WjUwGaQnFPlcoTyzFwkk7Ss3GTs3FpPo9j88Pj5oP/AAT6+AHixf2UdO/a6/b\
b+Idn8HNJ8caJc6P+zWn/AASwPg27/wCE++E1z8IfGWu+MJV+BugXXxJ8dSfDzVbrRW8R+ILfUvEOn3\
NzLLFqdrfXk1zdcB4y/bv+FHw8/wCCf/7Uf7On7JU3xG8daH8ZfAnxGv8A4l/FH9s34r/sneDtVfwp4\
Y/Z0+C/7Mfhn4f/AAO0X4K/Efw1pPxA8XxeAfgp4BtdMsYNN1PXrmXw1qN7e6f4ileW90L6v1//AIIj\
+Gv2+vj7+2r8VvEvxrufhn4Pk/bL/abtNe8KeHfgR4Z1D4j3njbR/C+u6H4T1bTfjRd+H7C40r4c2s1\
l4burzwtdaLdLKdL10aVrPh1/EGqXei/kR+yR+zP8Mf2u/wDgmZ+2D+194Q+I/wAKh8Tvht4E/bq8f/\
GP9lPxV+yL8QfEn7O/wBX40DwxN8P4f2ZLjUvFGjaB4G+MVr4Z+DC3Fv4y0rUPE0+l6N4n0Dw3rGk2M\
vh3SW1v934Aw/CPBfHGW4jhrw+x/EfG+QcTf2bg+bOcmwOGxmIo5pi8Lg2sLW4frKHsI4GlGnDEY6pT\
k50a9acaeHq4Wr/YHHnF/hDlOS47gziKedcc8T5Pgs1eKxOaZlmWKynC5rUr1KWHxU8vhQo+2l7PF1s\
dN061OksyrQoyqYin7atif3M+IH/BZn9trwbd+I9Y8Hfs2aR4y+GHgb4QeEf2gtd8e6n4H8R+FLzQfg\
drHizwx4G0j4meJfCOkftf6vPpWkXmveB/G19YWGnXGo65J4W8A6p4u/sqz0TS7O4t/p28/a//AOCoR\
0eZT8Lf2JnU6ZbKYY/jv4auLkqLXwCBGthJ+1WY5JwIYg0JUojWF2iqF0y0EXMftf8Awi+K37Yv7Tfj\
u7+Gn7BH7Nvxs0D9iTVvhd4F8c6v8c/jD8S/AXiL9ri6v/CX7MP7WNl+zl4a8K/DTwMnh/VfDujz+L/\
CF5bj4w2/izwNJ4i8fW09npLw3Pia61r9g/gZ8T7P48/s4/Bn48ad4bufDWn/ABn+CXwv+Lljod7DFd\
3mg2fxH8CfCvxlbaVd6rB4Ktku7m2g8RpDJcJPCkzzGRZWF2H1rxsJ4j1cRmOOwy4WyengMNPlwspZX\
hfrVSnGcozli60sBRwletH3IzngcNhqMp89SNGlCpTo0viM68U+Fcsy7KsZgPBXhjEPHxbqwxWHwGIl\
QhNRq4SMpZbiaVX29XDyc69XE4PL4znHkw+BoexrOf4B63/wXG+KPwQXwv44+OE37EXjL4J+Ifif488\
C+JL/APZ9/a6+D/jPxnDq9ndeO9Q8RWegxSftb6kl5qlhY+KtO1F4bmya1e21nR7TVL7Sn8WQXd1/H7\
+2d8Gf2R/2WvDeg6P8Dfif4n+Oer2ep/APx1H8cr+68H+FPD+iaD8SPA/xx8c+GPhBF+z34W0DU4fFn\
i7S9Pj8PDxb4r1Xxr/aGm6jqFrpkXhe3T7U+o+wfEzxP+z5+0J+wD+078GPhLpS6X8VtK/4LGeLv2kP\
gm/xkvvgpoXxYuP2X/jl8GviH4dubDSLyDVLSW4vbW/+Evw/Pj3T9JOnaLDqN74Rn8nUdtmukdF+2Z8\
H/h9+zv8ACj9j748/ESy+JnjH4ZftZfCDwr8S/HHwn+D37Rvh74Nx/wDCxfgz8LPh9p2lz2sfjn4M/E\
DRvGltpmp/tTE6JONNvr+Pw8fEFiRB9ovfEFyZ7wrQ8TcrxccP/ZeD4n4bwlepVw1KnRwlHHUfYUsRO\
FOhGgqmFxcHWl7PEVcPLDYyhQq0VUjVw9RQ+ho5/ldTJcw4lnkeG8DuJuHvYSpVMqw+P+r5zh6OJxNS\
tSll9CrWi82wCng50X9ZwmGnQxcsTjsTh4YTDVJfn5+yn+0vY/BL4TfEXxz4O+MHxA+E/wC1P4b+N/7\
MGqfATxL8KbHxDN420nwd4d/Zn/bL+G3xYvdJgXU7Hw9YWCa142+EFpqdxfSf29cwarKdBWSF9furfk\
Pgp8RviU1ppUfgPxs2gfBr4U/GCzg8OR/ETx54c0Sbwp4m8f6D8etX8J3cA0vVbPW5XuvC3h/xFHquo\
aHbLpkF9a2cOpPanUdLivO4/ZY/ad+MvwF8Ma7o1v8ADX9nbxh4B+M/h1PGNhY/tZfAf4FfE/wFqmsf\
s0/B39obQvAHifwpP8e5NJ0fUfGvh2P4h69aadGl5e3Or32oaXoh0jxQ9zY+E9W+SL/4teJPFWnavpP\
iXQvhFpyR+P8AxB8YrjxP4F+HvwS8CeK9N8UeK9W8HQ6pF4fu/BumaRNeeCbPTPCwg0PwFo93p/hrQm\
1a8v8AR9J057q9nuPyPOp5LLhHD5WsorZVxLGh7GTr08JicKqOIw044TGYSNXDYTEYbEUY4mdajiKNT\
E1akcdKWGdBSqwxv51wniM+4S8U8FxLjcbWznKa2Jw+ZV8PioYvD1MxwsamBzeOGxNKKx1OlRzCnQo1\
IvGVHg6mHoxxGJrexpYerS/0ov8Ag3R+P/7QnxQ/YF0S3/al+Ovw58ZeL/CPjXQtD+D1rf8AxO+HUnj\
Dw7+zFYfDz4AaB8HV8Zab8LdZjvdKMmt+HPGot7rxXDH4rvrfw5f3t5NcJZaTcxfor+1Frmnx/AfwRb\
T+JvCxnt/j/wD8E9Vu7VPE11LdK1t+0n8EW2C2uNRO97a0juIrsSqfslwVtoBFavLE38TX/Bvf+3R8L\
P2FfiX8Z774o6h4n1bwj8cvh78HNNk8NaBZfCRb+7+IPhHXxF8Nbaz0Lxfqq6paXDeA9Q8YpHEs9w2o\
W+s2dzeW85lS3m/pi1n/AIKZ/s7/ALR3hz4Y/Bjwj4d+J3hfxhrPxz/Yan0KXxn4U8LWukatd+Ff2k/\
gjqOraVa3vhS91CWyvpNJstU1BHuo7G1ki0WUTXV1ftZyt93k3h/4gcU+EOecdZdwvi8x4fwGXZhVxW\
LpxUoUaWFhXVarVg5e2hTjClKr7ScIp0Yuolyar7zhr6OnitgfErhvijJ+CsXmvA+UZzleMnmWGhSqY\
anhaeIwuJr1ZqlXquMcJBzWKcZVIUp0a16slTlMd/wUTi0Hxz8Z/j14B8Q+LdEvvBvxS07/AIIxfCbx\
/p3hf4m+L9Jv/E/w6+Jv/BRX9u34f/FHwrHq+ieJ7e7TRdU8C+KvFNjqbRXEczaR4pR2lWTULySb+X3\
9vD/g5b/aTj+Jl38Pv+Ccfj/wr+zX+z78I/FfxA+Enw50v4dfBbwjrPhPx38DfBJ0zw98H/GVjf8Axm\
stUfR9NvYLj4iyab4Z03wV4MTw1oOu6fpup3Xii/murjTf6p/2/wCx8S2nx0/aA8S+FPhx4y+JGqfDb\
w3/AMEdfjBdeA/h14csdQ+IHibw18FP+CgH7fnxW8Z6P4H0XUPDmjR674vfwf4C11dN0tb6yn1K8sod\
MtYpLkxadp3+aX8Rf2Wfjt+zt8RrbwX+0f8AAnx78MPEt54D1Lxv4d8FfF3wD8QPBGr+K9Fa78Z6R4f\
1Cy8NapceHdbt7W98Q+CfFFrF5iQXMU3h6+WaxkktJ7YfvfjDxc+GvCvgWlWxGGxNHE0qc4YOvD6xLm\
pcMcBTnWo0pVlTw1WcIxo/WJ0o1q9L29HD1404YuB/FXhnwri+MOM+Lcpymkv7RrZpgqVSrzNRoU8Rh\
VGlPExpUquI+r89Oq1OMZQhKE48k6lSmj7T8I/8FyP+CtHwp8Wa/wDFDwv/AMFB/jNr/iL4nvqGq6/o\
Hi3UrT4keD/CN3ceI49V/s7wt8Mvir4Rv/Cvw1RJtK0mSyh8Hada2On6da2GmWzWkFqlhblflLo1zod\
vfWD+JbZ7vRxp+rxvBa7b2YX02i3MOj3L2tlr1jIVh1eaxlZWuYflhcMswDwOV/OPFXEk8uzqWCwGSx\
wWGp4fBy5KeAjUgqlTD03WlzYv29fnqVeatNOSppVYqjCFJQhH9AyjhdZ1l0MyjnuV5bJ1Z0HQxOPeH\
r/uYUGq7pzTXsq3tGoyjOSdWliFyU4RhF/7fV7Zbft/+gbNn9rf8wny9nl/8J//ANSBD5W37J/0w8v7\
D/y6/Zf+JFj+LrLboHisf2ft26P4pGP7I2bfLsviNxj/AIV7H5e37J02xbPsXS2+y40POutHuR9sx4v\
nbH9pY8vRPhRHux/wmW3y/s0b+Xu2xbPK37PtNt9n8z7NpH23K8T6VPFoniSRvFTXKR6V4idoH0T4Vx\
w3CpaeOG8o/YmVoopAkYHkSBkF1bfZnY22jtedcYq6/eLf+9/8ifKnfW1luvbtfsG7b4j1CHZ/ZO/bs\
8QeEofs/l/8IBJs2/aNnk+TFs+1eV/Z8Hn/AGDVCyst32D/AEDfv/sn/mE+Zv8AM/4QD/qQJvN3fa/+\
m/mfbv8Al6+1f8T3loNHuftdwD4vnA/ty9AZ9E+FDxsg1rw2BKkc8axJalGkZYo3ayWKGeKGd7ObUJr\
YtdHuT9jz4vnXP9m58zRPhRJtz/whu7zPtMaeZt3S7/N2b/s1z9o8v7Tq/wBiXKv+fi/8m/8AkQNHw/\
Zbr3Uv+Jfu8zWNCP8AyCN/meZoHwjGc/8ACvZfO3fa+ubnf9txm6+1bdbns7XdpEMn2TfnTbl/N/s7z\
M7bXx23mef/AMIfLux9kzv+1Pj7Fu+0R/ZvM0TktF0qd7vUVHipoTHqukJK/wDYnwrkeVm0T4aSGW7+\
2NiSVUmZH3rArpYTfaUja51mS2nttIu/7NiJ8W3it9hnJR9J+Grzg/Z/F+Fae5tFuGlJWIB2iEwNxbF\
I2kt9JW8pxVmudfZ79vT+rPyuG/4gstt7pv8AxL9vl6xrp/5BGzy/L0D4uDOf+FexeTt+ydc22z7FjN\
r9l26JsXNltvbRfsG3d4j0+HZ/ZOzdv8QeLYfs/l/8IBHv3fZ9nk+TLv8Asvlf2fP5H2DS+B1rSp0u9\
OU+KmmMmq6ukT/2J8K43iZdE+JcgltPsbYjlZIVRNizqiX8P2ZJGttGkudWfR7n7XbgeL5yP7csgWTR\
PhQkaoda8SAyvHBG0T2oRY2aKR1smimgimnSzh0+a5nlj/z8X/k3/wAiB1NlZbvsH+gb9/8AZP8AzCf\
M3+Z/wgH/AFIE3m7vtf8A038z7d/y9fav+J7j+EbLdoHhQf2fu3aP4WGP7I37vMsvhzxj/hXsnmbvtf\
TbLv8AtvS5+1Y1zOtdHuT9jz4vnXP9m58zRPhRJtz/AMIbu8z7TGnmbd0u/wA3Zv8As1z9o8v7Tq/2L\
K8MaVPLonhuRfFTWySaV4ddYE0T4VyQ26vaeB28ofbWZpYow8gPnyFnFrc/aXU3OsNZnLH/AJ+L/wAm\
/wDkQOtitcx3x+yZ2abpT5/s7ds8zwRrF15mf+EPby93l+dv3Q7/ACvtP2i58v8Atm0/n0+OVrs/4OU\
/2aI/snl/8YCXT+V/Z3k/8e+s/wDBShfM8j/hD7f/AFXkY3/ZR5H2fb9o0zyfL0395Y9Iu9l3/wAVbe\
DFjp5AbSfhqSxPhPU2ZYzJaAxyiQLG7xB5nuHjuLiOPVEtrSX+f342afKn/ByL+zZbf8JA00j/ALBZd\
dRTS/AULw7dY/4KNlIYrbT91gWcRDyXYPcQreINPW4SHTXl+P46iv7Kyz30v+Fjh/v/ANDrL/L5/wDB\
0PbyD/fsRpf/AGLMv/Vfij7u/Y6+J3h3wP8AtHftvfss+P8ATf8AhB/i3qn7Uvxl+NXw/wBI1RNBmtf\
iN8NfHHhq68Tafq/he50jweBDrdpplt9qvtJuUsdRtrKFbwRINO1Q+E/Yv+Cm1rt/4J3ft9H7Ht8n9m\
j9pNM/2bs8jyfBsMezd/whkX2Xy/P27d9j5X2jZ5Fh532bUfM/iB+yf4S/aX1P9qjR9c8cat4W8c+Df\
2j9K8UfCf4qeGNK+G2m+Mfht40sv2Y/gre6drehX+iXdtcNpkl9pmkG90+2u447pILCS0mh1HTPDOoD\
yv8AaL1j4o+J/wDgkX+2bqfxn8XeHNe+J+g/AL9tb4f+N7rwpo3gK18L6/r/AMMNT8afDKfXdFNna2l\
xbQ3h8Li9UWNvbWqytcrYWNvYz3tnY/0z4dYfJM+4n8PuO8qxX1TNq3GmFw+c5bPnajjcVnuKxNHG5d\
Vkn7TBYuGGr+2oVpqtgcVBw5quHxFCVP8AR/FjD8PcU8OVfEvJsU8BnmJ+p4XiDKqvO408xx2W1sXQz\
LK6z5/aZdjqeExLr4atP6xl2MpumpV8LicNKl798af+CX37Onx++J3iP4q6xqv7RHw71z4vWPg3Q/2h\
NE+B/wAePi78JvBn7Sfhbw/4b+Hvg3Q/C/xk8L+D9HFvrOnQ+Dr6/wBKFzpQ0/VLiw8RTW8+o36z2p1\
XyH/gpD8bPEX7Bv7HPwQ+HH7MVt8LfhDrPxP+IXwe/Yt+DvxE+KNxHpvwu/Zr0fXPh1Zy6N8TNaXWvA\
06a/Y+H/CvgN4LOG+u3tUudWttU1RtYsIbzT/Ffqnx1/4KK/sa/sxePdX+GXxl/aM1rRfGngvwd4U+I\
Hj/AEvwr8CNV+Ldr8NvBviPUvBOj6Jr/wAUdd+F3w11rT/h3ZXOpXdhEg8RXWmSTHWLMzpGviCRl+mv\
FngD4Y/Hv4Tvovi278D/ABq+Evj7w94a1xdF1/wl8EfiH4A8a6Of+Ff+KfDOqpbXWmX9p4isftdvpmo\
WN0sE5aXT/tsQWabUWsv59r4bD4ilmeGyfGUMFm1SLUqlOMZVac53cZVIpKSbbk05Wd+aS11PlsozTG\
ZdmPB+a8bZVjeJOD8JWjOlg8TWxNPDYrD4d06dajhKs701GEY0qc1RvFKMKU7Rsl/mP6H4T8V/He0+O\
uh6v8evAd18erb4s/DjxXYXnxW+JPwp8HeKvHXg+20/9odPi341T9ov9o/x1oreGNesfG/i/wCH6614\
KsfGOkTeKbnx/J4gn8N69F4OXUtG0NcT9nv41/CT4FeDv2j/ANob4q/B/wALeAfgPNdfBzTP2nfi98c\
30DxL4l8UaP8AC7w74h8Q/Ajwd8BP+CfXxLi8KfBPSPEvwR8deGGsNZ1yG71VbvwnqNpJY/2Dr+nT+E\
XXiW58LeL28NeErvW7TS7e519JYtPg00eL5NNT+1IbDTPFXguRrvS7Tx+v2Cf+2biGJpUndoLeWCIOJ\
vCvF/jb9pz4h6P4u1nxVp0vxe8Mfs+6FYfC+X4tXXw60j4rfDfwH4U0PxxpXhXTZbD4hTadfWHhnwkN\
T8YeG9P0y2svO0mdvGlk9nbR3d5Z3Ev454cYjNszxmLyKviadH61HCYetzY2pQrZlKeJrUKajNYOssL\
KE6jxSqVJ8tNU4zjUw8k4V/8AQb6Q2C8MuHsgo4qlWzBR4nxOPxeX4PDZHhcTgcjWGoZHjcVh51K2f4\
CnjVHBzeD93DYd1Z+3UqmYSVD2XoWh6pF8TP2Wvg38H7PXrW+1Xw98V/Dk17pcsvh/xjpOj6Zc+Kviq\
JNT1fwhoHw30/X9BkE/ia0jVr3X9Qsb6DU3Wf7FD9max+gf2b7H43fEHX/E/wCwP8Pj+xbb3nxq8XaN\
8PPD/ij40/Ab4ND4gQ6/8bviv8M/2cdFi+F3jvxt8NPE/jyxudEudc8I6va6f4IuV1Tw/pXhPXPE2l2\
8upRardXn502/xa0nT/HEvjHwh8NPBvgi70rSLdtN0zwz4i1i28IyaloOg2djd6rd2Pi2a6vtZGqXel\
T6reacLyGF7/UWXSrfTraGx063/Qz9nj4OftZfs6/EL9mH9u68+Ef7Sg0L7Z4d8WQa5a+D/jl8FNE+I\
Phj4h6RNquo6H4D+P3hvTLmVX8S/C3X/FFrHqenq7C1vptRhXULOKW2T9CqYzi6h4icQ1uLcDPiCWY0\
8RTy/CYilXzapSxM8Q69ClRr4SOLxccHQw9OeHoVadWjSqwlC1OcqSU/zrhinwVxf4XcP8M+GWCxGYe\
INOphKGZ4ieY1q0auUYbDYfL60cDl3E+KoYSvj8RVxVXFUMpy+GIhlMaVT6pi8HgqyjhfAP2pvh94g+\
F/i3wt4b8TeOfgR4k1LxF8BvhXJ4bsdJ8L+E/CO600nwL4d0S3vPH1t4X1ONPht8WpIvCcE12+syw3v\
i03tr4z11Lm68W3GoXP2L/wSw+LHxf8GfGb9j7x3+01+0Je6F+yt4e+Lfg/R/hJYfGf9ozQo/AHgy58\
MfHT4E+J/Hmq+Efh34v8du/gXwzb6VdtJeazFpVlpMlxp+pWx1D7XpeoR2n58/Fb4w+HPjb46MX7RcN\
94X1T4ceFj8K9Hh+EPw28N6PrVreeEPEGi6bpmqeJl1a60268YaiNB0rxFbXt74h1K41a3ku9L06y8n\
R9Os9O0j7c/YH/AGa/gV8cbLw3oHxV+NXxD+GbfEnxj4V+HXjm50m++HKPrfwv8R/G7wD4R8X6/e618\
QdS1Oy0Lwhpvg7T9RNh4t0zTXjtdd8Ny6fe295ZzO9p9p4ecN8VUMmzziOpglj8bmmR8RUMxw+Cp5bg\
6mGw9LIsdgMwxbw7xGXOi1VxOBrLD0MFi8VjcNUx8qNGrUoqkuHwzyfiviXjjhXFcPUqOc8QcCZXicS\
sJSzaFbHKU6eGwOKweNwtXETtXwdTHYtRw9DG4XB4jB0ZfV1GtTxTxX+iV4xs/L/bz+NDfYfK8v4K/w\
DBPMbv7K8jy8fH/wD4Klx43/8ACCWvk4+zbceZbY+y+XsX7P8AZdK/iv8A+Djr46WPxR/4LMf8K1tvB\
WifDfVv2Vfhf4d+Edx8Sodd1658R/ElfG/g/XPj7pq6poFnp+n2/hPQNHi+LGsaVZRWWhzai13Jdzaz\
qradf6Jonhb+jbwH8QPHP7Pv7f3iL9mn9rP4x2eueO/F3gT9jDwl+z38W4tH+HcUfxg8C+CPi/8At1y\
eG18c6w+q31xoXxVvNQ8c6hp9vBOssmqT+HPIbU9YuZPD2p+Jv5ov+DjzxL468X/8FiLtNasrO/8ACX\
wb+G3w5+B/hHXdF0fS7a+1KLXfDHiv40MuvWXhqeaG51AeIPjDryRXVtDHYw6XaWduJHWzkuZP136Tn\
BOa5ZktDD0Es5y7EcK5XXwWPwsKs8NjsJ/Y+UYBYrCe0pJzjLEXw06dSEZ0K7nQrQjXpypH8o+B/BGc\
8KfScnjKdOOf5BgM74czXCZnhfrEcBmGWYfN1gv7Sw1dRpV44ejjF7PFKXsK2ErUa+HruhWpTUfwsu7\
DS/EPw8+G0dr4Z09/D9poXxt1l5kPjBorCw8LTXmsQKpg19cyX0+lQTSR304R54RFazWYKrRXG3mq30\
Hwi+E2mafZXF811ovxokuYUkezUQwHVFuLszzQlL22ttNu9QuXhQ7me0jG9XAVivwXi/D1MdxDDEfXZ\
vBwynIKVN0KqjF1KWTYOOI5/Zuzqwqfu5ppODgoP4eWP6j4jcWYDCYXhT6tw3l2JzavgMtqYupiMspO\
EY1OHsgqYfDYaXsoR9jRjOpUVNVakqSxChy0qfsub/aUvb3d9v8A9P37/wC1v+Yt5m/zP+E//wCp/m8\
3d9r/AOm/mfbv+Xr7V/xPcfxde7tA8Vn+0N27R/FJz/a+/d5ll8Ruc/8ACwpPM3fa+u6Xf9t63P2rOu\
F74gvW/tD/AIlusPu/tfprugSeZv8A+FhYxn4uS+bv+0rj/Xb/AO0Rn7V9qb+28vxTrt3NovieN7PVI\
kl0vxOjXEuu6LJEiy2nxIUzSeR8Wp5JYyLoMdguHkGoDaLo3RGt/RRV5R82uqP5wOstr3be3bfb9u7x\
HqE2/wDtbZu3+IPCU32jzP8AhP49+77Pv87zpd/2Xzf7Qn8j7fpZZXu37B/p+zZ/ZP8AzFvL2eX/AMI\
B/wBT/D5W37J/0w8v7D/y6/Zf+JFj23iC9F9dt/ZusLu8S6jL5n9u6AgcN4i8IS/avMHxcj3qwgMnm+\
dKWFmZft85gF9phZeIL1f7P/4lusJt/sjrrugR+Xs/4V7nOPi5F5Wz7M2f9Ts/s44+y/ZV/sRWAPD97\
tvdS/4mG3y9Y0If8hfZ5fl6B8IzjH/CwovJ2/ZOmLbZ9izi1+y7tEns7rbpEMf2vZjTblPK/tHy8brX\
x2vl+R/wmEW3P2vGz7Kmftu37PJ9p8vW8TQtdu47u8ZbPVGLapoTyImu6LG1k0ei/CWPyZvM+LUIjkV\
LISfuzEiJajm1ktSNDdZ67ero8Kf2RrKEabcp5J1jw/GVza+PR5XkD4mxBSftIGz7KoP9oAfZ5PtLR6\
zbXutd+X8n/n+fZgaXiC93Xum/8TDd5msa6P8AkL7/ADPM0D4uHGP+FhS+du+19MXO/wC25xdfat2t7\
Fze7r20b7fu2+I9Pm3/ANrb9uzxB4tm+0eZ/wAJ/Js2/aN/nedFs+1eb/aEHn/b9U5PXddu5LuzZrPV\
FK6prrxo+u6LI160mi/FqPyYfL+LUwkkZL0yfvDKjpdHm6kugNc1LnxBem+tG/s3WG2+JdPl8z+3dAc\
IF8ReL5ftRkPxck2KonEnm+dEVF4Jft8BnN9qcWem2vmv6XzA2LK92/YP9P2bP7J/5i3l7PL/AOEA/w\
Cp/h8rb9k/6YeX9h/5dfsv/Eix/CN7t0Dwof7Q27dH8LHP9r7Nvl2Xw55z/wALCj8vb9k67otn2Lrbf\
Zc6GWXiC9X+z/8AiW6wm3+yOuu6BH5ez/hXuc4+LkXlbPszZ/1Oz+zjj7L9lX+xMvwtrt3DovhiNLPV\
JUi0vwwi3EWu6LHE6xWnw3UTR+f8WoJIowLUsN4t3jGnncLU2oGiFna+n3r+v8uoG3FdYjvh9rxv03S\
kx/aO3f5fgjWLXy8f8JgvmbfM8nZtm2eb9m+z23mf2Nd/z6fHK63/APByn+zRJ9r8z/jAS6Tzf7R87/\
j41n/gpQ3l+f8A8Jhcf63z87PtR8/7Ru+z6n53mal++UWu3ojvh/ZGsjdpukpj+2PD6+Zs8C6zbmID/\
hZq+YUMgt9m2YIZxbi3tlkOj3X84v7Zup6Tp/8AwXu+B/jrx58PPin4x+H+mfsYeEvCusr4A8B+PPix\
qUPiLxP4i/4Ke634O02S0+E/iHW7uzub2Xwtq9/b750EsPhu9upEvoY5pdT+U41jTnl2Ve2m6WHjnGQ\
SqzSi3TpQznL5VarU50octKmpVJOdSnBRi5TqQinJfRcLUJYrN3hoUq1epiMLmEI08NQqYrE1ZTwGJj\
GlhsLSTq4nEVZNU6GHpr2lerKFKHvTR8yft6ftn6D8Cf8AgtV4O+N/jvwj4kn+Bv7Anjf9o6++KvjPw\
t418Dar4w8UeMf2wv2CPgL4I8B/Dnwz8OdY+K1ndzzSz6boeoWNxPqhHiC3tPGN7YadqWmfD7xbrDfX\
eh/trXP7Uf8AwS//AOCsngnxX8MNY+EPxP8AhZ8LP2nvH3jDw+PHdl8SPBV7on7VuneL/j74Fk8I/En\
S/EUFr42Mej6zdRTSwWd3Be2VnpXiCyudS0rWNNutO3vFHwx+GOm/tM+NP2oPgTH+0D8HfHmumUeH9b\
vP+CSPxe+K3xA8IQN8N7/4Z6pZeHPin8QYLrV9K03UdB0q0jltrRoLdLbxLeWrx3SXOpvrvjvxD8Kp4\
H/Zq+MHwF0H4yftFfB74IfGrVNR8BeMvBnwa/4IvXnwisvEcvxs1/4cfCiafTbPTLLStOl8c6rp82ka\
dZyTtNe3dxpmm2K3F9cLp5s/oeCfEePB3GvDLo5bPGcLZPxBhMxxVSnmPCcamMjhM0xuJhiacauf0al\
OUsPjFCnSrVIuEabjWlNzp/Vf2HNOF54/gTNOH8FwjxOs3zaOUVqdfE8I8b4aNCtgMDXwsqFbDw4cx1\
C3+2Ynmq0saqNSpUp1FGhDDz+t+i/ty/Efxt+yF+0/+0toHhL9pH/gnh4Tg/4KY/D/AOElrDon7Wuo+\
LNG8ZfB/wAU+Ffh78Nf2fbjxf4vXwd4F8WaT4z/AGfrvwn4Mli0+L4lal4a8IW/ia/1OK3EEWneINN1\
D6E0b/gp3+xH+xV8I/g5+ydpvxQ8RftAJ8C/2ffg18MZfiP8JpPAuueDtYHgr4ffDLwpavJqF18c1tH\
1SWx8L2lzdwWC6lZ2Et5Fpzzi/sp7Lw/+BXxg/a914/ET4+eBf+Ci37dX7Uf7J3j740fBnQvgPeXFh/\
wT98D+DfBn7S/7H3h7xZ4uuvAOv2WkfGq4t9d+GvjW2vviH8UtP1zSLO6lhsrtIn0bxJqlssFx4c/DG\
f8Abd8R+HJV0Xwt4t8Jahodv4Tg8JQXd54c/ZtuLldO1FbDUdSMMmu+KbmaLxBbahfahbW+smV9Thgt\
Vjtb6GzjihtFk2M4T4E4kzPHeI2Fni8qqRUKFLI8fkHEc51sRN4qM5Ry7jTCxo0FGVadadOo5U8VVp4\
TEU6FSh7OX9B+BXAHhd4hZTjafjTXzdYbg6ll1HD4KGExWQSxWKxeCdH21bE4jh2ljcQstwWW4LCRw0\
XiIU4zhia2Lo1MZ7Cr438XH+E1h4M+OXx++F3xg+L/AIjuR+2j4/8Ahz8LvBvxI8O+DIfFOpfBLULXX\
vFnhb4gfEb4teHfidO8/wAVXtm+zarpun+G7vSrqfV77UIfE+fLs5vvj9jb4ead+zV8APj3cRftC/Fe\
Px78bND+Gnw+T4S/C3w58L9Z8HeF/Bd7+0D+zl8Vvin8UNO1f4tfGjR9MvfizafDH4WfEPRdL0W98Oi\
0ujqFsJ/FFoJnhj/Pv4xeNPgZqHw9+G3gz4e61q1rbeINN1b4ifF/TdF1X4c6PcaX8cJfEfxK8A31vF\
rOu/E/VV1jRNT+F0fg3UJJrNbCyUeIvshsDeWd9d6h9v8Awr/4KZeAvhx8I/Bvh3W/2d/2YviJr1kdf\
0a81XxX41+OFp49k0+xkum0PVfEcPw6/a20Dwwtp/Z3iOPTdOXT7NLtovAQl1e18y5lvtd+14Bx3gRx\
9neYYDiPAVOGcLmGUyq162Z0Mrkp42TwuHnD6zjeNKKxDnhpN0sLicXiqVLlxfs8twUp4pVfs+HOGvB\
6hg62E8V8y4m4iy7KsJg8NlKyCo6WNy7MHUzGea5hShj8DQwtGlUlTyf2NSdKoqsqGHcfrNJx9l+gf/\
BL7xf+yz8AP2pvi3+0j+2v4C8dfG7xdofxz8HeK/2P/HXib/hVmpeMvCGkaM/xO0DVfHXi34ZeD/2gL\
fwZ4S+MF7oPhb4A3Iu9PbWLrTtS8GtLpPiWxltVvb/+hf4wf8FeP+CePx++Hep/DP4meBfjHreh6xpk\
tpZXtx4U+Dmr6t4Q1bUvD3h3w1F4x8FSeIvj1dW2ieM7HTr3Uv7Ov1tg9u8kQVIomSPSv5IZv+Cs/wA\
N7mawuf8AhjX9keIRalBfpEvxN/aOVJSJNZkFpd+f+320kFqRqDKz7op0FlA4nSWWeS6Lj/gqZ4P8R6\
bqOhaH+yN+yto+rXuialFY63onxM+OUuvaRNbaTYz/ANsaLaeIP267ywu9bt00sz21tc2F5BNczPB9h\
uBHbW0H9C8GcKfR9yPHZFg+GvEHD082w1ejTwVSjUyVYiNV1FHD06NLBeIcP4blGjQoYeg7U1CjTpy0\
g/s8tyD6GGX5lgOIavDXihSzfK6lKvHNqmMwNGrTqUoU+bHVpYONKmqj5PbYmrSoJ1nzVJwnOcub5Z/\
aS+ENr8SEv779mQ2Nr4fT9oL9p/xEtz4i8ZeDfBnjrV7bTvjprVt8Htf8bT6ZqttZ+IPG9j4TOuWsVy\
CINPbWrw2VxHayNsxPhl4E+LPhD45fDnUNeubvWNE1jW7hG13TPH6ahY6L4JtvDk0+leANY8K6LrDWF\
vpq+LdTtru1dmmknu7N7iSMXJmV/WvgJ+1Da2+i2R8R3fhWw0DWPiP8UZrk2viLwvaazo2oeIPiVrPi\
GyOuWmr/ABOs20nRJPt+YtQjgurYm18p50BjvIPd5PidP8Q7T/hH/BUmt2HheKXQvDnjf4heH9c8PPe\
6dda74ektNJ0bwLqttrOoWGp6wdVvtNt9VuElkl0a3vgkMUd7cRmz/rVfRGrePGJ4Z8QsB4k0OHfZ5d\
hOV4fI6NCjVy6qsHWnWr06edvE4yeMqQnFV5VpOtmNSdN0asqVPCw/ZOA8L9Hml/qn4iZFxTxFj/ECt\
PhDEvKKWIhUp4nM+G8rwrUaeCq5W6WHoY7DwxWIzrM61WH1an/aGZyxWDhDF1Jfe3gX9pG88bap4q+G\
nx1tB8WfgH/wjPwW8AJr10b2++JPw7uP2d9Q/a98TeBrD4K67N42s7M3mieN/wBoP7PdTalHq1pHpt5\
qHheGQwWt9ot1zf7dv7Pf7VvjXxZrXi7Svid8OfG3xO+Jvwt8Oahp/wAQrDxd4+g0r9u34K6FLY674T\
i8RWmu+JZbjQ/2l9D0bwN8N1n8F6oiSeLZ/CWjTWkNx8QDoeofFb0f4TfAXwX8VPh3P4W+AOkSeFvi5\
8OfC0b237P1rNbXFj8V/C3hjSPFl14v8bfCfxDrPxDmvNT+Jn2W1stR1XwZLBfXmrz3msa34dv5454/\
Clp+bX7aX7QX7Qfgz9n7UPgz8JrwWnhLx/4luPF/jBLKw8GW/jbSJPCd1puq3XijwJ4/luJ9c8Ka5Lp\
ehw6ZdjS7vbfaRrV9aXVtcxXLtP8Ao30iuIvD/hThHjLxA/sz2eX8DzwEMwy2phaFHFUp4+vgMrwWbY\
dVqkMNRliGsNLHOjiJZfmtHCVKPtv7Uy3DYnCcXiH4DcNYTKeNvEHh+tm2T8e4GU8y4p4bySWIhD+0c\
wrVcZDH5NRWXyq1lKc1hZYijSp4HiLCZdH608HnOU0MZlfxD4c8R/tCeDvEOg+LvCOveDPC3ivwtrOl\
+I/DHifw5qnjfQ/EPhzxDod9Bqei69oOtaZPFc6RrNnqVrbXFrdW8sc9vPbxyxSJIisCvE/gP4j+N/x\
r8S+Pb7xV4yvfHusLZ+IPHniXxN4s8fTar408Q6/rvh/xJ8QL3UdQ8T654gYeItZlh0HX557eaeXWLr\
VLmOwjhub+U2oK/wAt+JPpl8FZf7Krm3hlh8enWrYeEpPCVGpUqOExEv4kbRjKnjaEopSb1bkkuVy/I\
eA/Cqn4tcJZLxlDFcSexzGnU5aeLqe2nTlRxNfCYmEJvCy5oU8ZhcRQ5+WnzzoyvCLTiv8AYdvbLb9v\
/wBA2bP7W/5hPl7PL/4T/wD6kCHytv2T/ph5f2H/AJdfsv8AxIsfxdZbdA8Vj+z9u3R/FIx/ZGzb5dl\
8RuMf8K9j8vb9k6bYtn2LpbfZcaHsXtlt+3/6Bs2f2t/zCfL2eX/wn/8A1IEPlbfsn/TDy/sP/Lr9l/\
4kWP4ustugeKx/Z+3bo/ikY/sjZt8uy+I3GP8AhXsfl7fsnTbFs+xdLb7LjQ/x2O69T/Jo2Lay3Xt2v\
2Ddt8R6hDs/snft2eIPCUP2fy/+EAk2bftGzyfJi2favK/s+Dz/ALBqhZWW77B/oG/f/ZP/ADCfM3+Z\
/wAIB/1IE3m7vtf/AE38z7d/y9fav+J6W1luvbtfsG7b4j1CHZ/ZO/bs8QeEofs/l/8ACASbNv2jZ5P\
kxbPtXlf2fB5/2DVCyst32D/QN+/+yf8AmE+Zv8z/AIQD/qQJvN3fa/8Apv5n27/l6+1f8T1AY/h+y3\
Xupf8AEv3eZrGhH/kEb/M8zQPhGM5/4V7L5277X1zc7/tuM3X2rbrc9na7tIhk+yb86bcv5v8AZ3mZ2\
2vjtvM8/wD4Q+Xdj7Jnf9qfH2Ld9oj+zeZokHh+y3Xupf8AEv3eZrGhH/kEb/M8zQPhGM5/4V7L5277\
X1zc7/tuM3X2rbrc9na7tIhk+yb86bcv5v8AZ3mZ22vjtvM8/wD4Q+Xdj7Jnf9qfH2Ld9oj+zeZolv4\
X6x/JgQeILLbe6b/xL9vl6xrp/wCQRs8vy9A+Lgzn/hXsXk7fsnXNts+xYza/ZduibFzZbb20X7Bt3e\
I9Ph2f2Ts3b/EHi2H7P5f/AAgEe/d9n2eT5Mu/7L5X9nz+R9g0vH8QWW2903/iX7fL1jXT/wAgjZ5fl\
6B8XBnP/CvYvJ2/ZOubbZ9ixm1+y7dE2Lmy23tov2Dbu8R6fDs/snZu3+IPFsP2fy/+EAj37vs+zyfJ\
l3/ZfK/s+fyPsGlwAWVlu+wf6Bv3/wBk/wDMJ8zf5n/CAf8AUgTebu+1/wDTfzPt3/L19q/4nuP4Rst\
2geFB/Z+7do/hYY/sjfu8yy+HPGP+FeyeZu+19Nsu/wC29Ln7VjXNiyst32D/AEDfv/sn/mE+Zv8AM/\
4QD/qQJvN3fa/+m/mfbv8Al6+1f8T3H8I2W7QPCg/s/du0fwsMf2Rv3eZZfDnjH/CvZPM3fa+m2Xf9t\
6XP2rGuAE8VrmO+P2TOzTdKfP8AZ27Z5ngjWLrzM/8ACHt5e7y/O37od/lfaftFz5f9s2n5R/EKy2/8\
FbrL/QNmz4afsdf8wny9nl/Dj/g4b/6kCHytv2T/AKYeX9h/5dfsv/Ei/VyK1zHfH7JnZpulPn+zt2z\
zPBGsXXmZ/wCEPby93l+dv3Q7/K+0/aLny/7ZtPyj+IVlt/4K3WX+gbNnw0/Y6/5hPl7PL+HH/Bw3/w\
BSBD5W37J/0w8v7D/y6/Zf+JF4nEf+64L/ALDst/8AUzDnjZ9/uFH/ALDct/8AVlhD9bb2y2/b/wDQN\
mz+1v8AmE+Xs8v/AIT/AP6kCHytv2T/AKYeX9h/5dfsv/Ei/Lr/AILJ61F4K/4J4/H3xnear428I6R4\
K+J/7PvijxL4n+GYg0T4leHPB/hX9sX9mjVvGWofDjWbnwlbJoHxAtvCsGsf2LO1xpf2LU57VgNLLiK\
//UW9stv2/wD0DZs/tb/mE+Xs8v8A4T//AKkCHytv2T/ph5f2H/l1+y/8SL4k/wCCgPiuD4b/ALO914\
5uPCet+Kx4V/as/Y4vrfwn4a0/w3D4i8S39v8At5/so2+m+FNCm8ZaBpmj2GsXuoXlrY2x1fUNG0u2m\
1VP7RbSbOWaO/7czi55bmEE2nOhVV0uZq9OSuorVvyW+x93wfXp4bi3hfEVqio0cPmOCnObqqioRhia\
UpSdaVo0lFJv2raVO3O9Efx/f8N7fBD44+KP+CUmqftQeHPH3xYuP2avhb4k1z9qPxXaaN8PfGXxO+M\
V/wCGviLqPgn4f/Bvx8vjL4fWlp8TND0zXfhfpN9q99qOoanba9p/xh8QyPt8RTatd6z+pVz/AMFPv+\
CMJsJIh/wTvdHa2ggEw/ZH/ZKwsn2fwx+98yLWEcITazkuLhTm++adme6fU+E+MPxr/Z2+DH7dX/BJH\
/gpN4W8I23w1/Yh+Jn7PfjL4c2PhTw18Mx4T8Q/B3UrdfE91481Xxp8L9D8DjTLXSrLxV+0NpY1X+wP\
7fuby60rXru1h8QfaNGn8U/Pf7H/AI8+H8nw18caSnjDwdJqtz/wRP8A2yvCFnpq6xokmoTeLX/ah+M\
XxM/4Re2tBokkn/CRH4aSHxB9iQ21y2hS/wBqeXNYSZu/594zr5vk2fYWeX1Mplg8wX1f608ppVXicT\
g8uyLF1OerWxNSdSv/AMLcabi5KapUKMvejVjyf7JeEnCfBXHHgxkOZZ7w9xgsPwphKE8PDA8WZnleG\
orN8943/tHDqlhsvhQbyWrw/Qji8RRhDCyqZlGhGhgPqns63in/AAUj/bP/AOCdHx2+C+n+CP2W/wBh\
m++GvxXtfi43i7V/G9t+zT+z/wCAYLvwVaWPxbtj4WufGHw7sZNRu1e78TeEXNrHH9iRfCjtIyvY6fa\
Wngfgj49/su/Gj4j2PjL9sL4GT2XhC/j1W/8AiB4V/Z8/Zs+C3wms7DS7Hxxq/jPwT8Avg7oGiXujt4\
X8ItftZ3PjL4l30938R9W0nRrL4baDqGh6HZa34q8Q/wB8vwh+IPgD4yfDLSPin8Lda0rxl8P/ABt/w\
l+veF/E2jaZItlqGnS+IPiqpJin+HNpNpl/b3FhPBd2lzFZ3en3ekT2l5DYXWnzR6B6ne2W37f/AKBs\
2f2t/wAwny9nl/8ACf8A/UgQ+Vt+yf8ATDy/sP8Ay6/Zf+JF+iZFwvxHlVXMc4yfifKK2Lz+jhY/Wp8\
PYfEqFKhGr7KeB5sc6eH9rCu3OpQt7VRoybk6cGfy1L6X3BWQZXDw+zTwI4iwWA4axmac2Fr8eV6GaU\
MXi6kFi6ONxtbhZ4+dWhicNSqKnXaq4XE0X7H2ClVpz/hV/YM/4KIf8E7/AIG+A9G+Bv7Rf7Gnhb4x6\
X4R+I2rXfwa+PNh+zV8Cr7xt8Wfh5qPiDx5fyaf8WdJ+I1/eTaf40tda8RWUVstvrGsaeNPW20aWCca\
HYX+sfZvxy/4Kr/8EzNG+A3xsH7Nn7JPin4D/tC638Evij4I+Cnxi8G/s+fs8fDfxN4E+Kfjv4ew+Af\
BWu6T4/8Ah/q6a34QnbxJrFvEdQsZ1nhi1h5mneJr2XUvqr4//wDBJD9p/SPBnxD/AGS/2cPFP7O3jb\
9in4nePrXxX8Kfht+1dH8dtR+JH7KvxJvm+JtreR/BH4geB/Bct6mgw3i3+oW5vZZmvZr2XTdT0DU55\
vF134j/AD7/AGnP+CX3/BW/wJ+zf8bviX8bP247X4kfCP4Z/Cfxh8WfiB4Gu/2iP2rPFg8S+Fvhx4c0\
/wCIN/p1poHjH4ZQaRq+rGEWb2SX11b2bXlvA7XcKTWNxP8ApmJ8LP7Yx0s9qeLfD2XSq1fbThPhenQ\
lOL5ajqfuce5YXESk5qvCmvZ0q0XUw05U5QUPpY+JngDxdhM/q43+1cJmfEcqiw0X4g5vhMPRWJwtGE\
XPKXk2MoStipV3Wy6qvq1OKjhoYnHUH7d/Mj/8E84/2iv+Ce/iH/gpD+y9P8ULfVde+PH7XPiXx58Ov\
HniDxb458aeOvgb4n/ak8U3vgfxbqfiuSfV5ZfiNpHhDxnocvjKTV9du7DU9O02fVru9sdZsJW8Xfjz\
onxIv/AkFvFIr33h2/8AFfgh9T00CFpY5R4u0OJdR0151IgvUQrvXKJcpEqSMkkdvcW/7mfsEf8ABNT\
/AIK8fFD4FX+rfCr9ry++BOhaJ8e/2kfhvrHwu1P9oz9onRL/AMK+O/h5+0F4o8A+ObG5s/g14Q17w9\
dSJ4ra4X7RpeqX0d0IRIju91ZLdfg/+0Z8PfH/AMDvEXibwJ8ZvDOueBPHPgzxZ4Mk8W6J4mt5ItRs0\
uPEXhrXbXVvNUumq6RfaJe2Wo2GoW0k9nqen6nbahYXFzZ3UE8n97eAfE+PymHCmX5TxRHNeIMieXyw\
0cPdTp0KlHDQWHeFdNSlH2qmpe9WjVhiIUJwp+yj7bXwr49q5H4c53hKXiDhM2zfhTKa+JpSoYh3wWX\
zy2Klh68K0IudChUjV58RKrWp1aOIp0asaMaUHX/VLwne65JpVp8VvAj65DpHh/XNCk074g+HLfU7K3\
8OeKb4eLtZ8JJF4ksdGi/sDxM//CH69c2EZltrwN4TvZIVjbTpzp939tjxf4M/aOh8GfFS50W5+Hf7Q\
sWstpHxa1nw54R0T/hVXxCHiB/FY1L40z6TaWunr8O/iHPLYaBb6tp1lZtomp3f23W0k0e5uX0+L5E+\
Engj9vTXv2V/2tPA/wAPPBMsXwQ8U+GvBvxN/aA+HE8Pwu1zxZcfDX4U6xceINC8V6p4Y8QG48SWVjp\
WpjVLzxB/wjcIttOtTZp4rcQWsTp4r8Dfh5+1nrhb4f8AwQ+G9n4iufE3izw54E0rTNX1X4ZeA/A03j\
7xVoHiaTwf8O7n4geO44tB8N+K9f0TwP4pj8P6Pd3trLrV34anttNgnu1fYvpRePXDXE/EeJ+jh4weG\
9fIXxhk83SznBVsVjMTRq0I0swqZfjsgo4Whi6+AljMDQxGI9lmE/q+GqYPHwdKtQWLo/6HZZ4yZbj6\
VfxO414HxuRYPw5nTnUx+DljMPjcPgcXgcHifZZjh69HB1MLHHYl/W8Hl+IrVJyp0csxtBf2hGmqRJ4\
C0vSpLHWtL1XTtS1bVLaxm1+LT/AkegX8t1YaPpml6Vb32rRWKtqy29vqF3FAd7JGu5YyI5oxKVetYf\
2lda+HnjLxtd/DmHwzpnw++Ktt8DfiHoGsv8IvDfxS+HXxSex1bVdN8N+L/hsyr4k8MtNB4B19IL250\
5NNnvPCupaUbptRs9RsYiv8UvHjwmw/BHH1fIa3EuS8IZhhMJgY4nKMdlfF3D+IwNSGEowi3gc8w+Z5\
g446jGnmPtqmMlSnPF1I4ShhsDDC0Y/0p4V+NfhjxzwvHiPw94R4t4r4YzCvXqQxuTYLBZvhauInUdT\
EqeJpZpUhDERqTar0bxqRq80q8fbyqyl/p93Wk+CX+2bNI8Ktv/tLy9miaQN3m/8ACZeTsx8Posbvt2\
nbceTj7RBj7Nsj/sXK8T2Hg2HRPElxa6d4Zimj0rxFNbTwaNpUUkcn2Txw9rLBJH8PIzE4a900xlREV\
M8BUWxSP+xe+vb3d9v/ANP37/7W/wCYt5m/zP8AhP8A/qf5vN3fa/8Apv5n27/l6+1f8T3H8XXu7QPF\
Z/tDdu0fxSc/2vv3eZZfEbnP/CwpPM3fa+u6Xf8Abetz9qzrn9eRkk1ZNNPTX/gH/JIZ0Gk+CVu7h20\
jwqI21y9uEZtE0gobWTWvDc8cqg/D6QCA21reMqiGNQkMoFjArPZamWuk+CU+x79I8Krs/s3zN+iaQd\
vlf8Ib52/Pw+lzt+w6juz52fs8+ftO+T+2uptr3be3bfb9u7xHqE2/+1tm7f4g8JTfaPM/4T+Pfu+z7\
/O86Xf9l83+0J/I+36WWV7t+wf6fs2f2T/zFvL2eX/wgH/U/wAPlbfsn/TDy/sP/Lr9l/4kSvHs/v8A\
+ABwOi2Hg1rvUUn07wyy2eq6RCqS6NpTrbRponw0uJ4lV/h5KEQTQas7j9+Cy3LMbkyyjWZ7bRfBqab\
FE+jeGVmFjPGyNoulGUStb+L1VSx8GSkyF73TwD9pY5uIcTxlEk0ff8P3u291L/iYbfL1jQh/yF9nl+\
XoHwjOMf8ACwovJ2/ZOmLbZ9izi1+y7tEns7rbpEMf2vZjTblPK/tHy8brXx2vl+R/wmEW3P2vGz7Km\
ftu37PJ9p8vW6bVm2m7cvXy06eS+5bWA5LWrDwat3pyQad4ZVbzVdXhZItG0pFuY30T4l3EETKnw8iD\
oZp9JdB+4AZrZlNsYoho2rPpPglru3ddI8KmNdcsrh2XRNICC1j1rxJPJKwHw+jBgFtdWbMphkUpNED\
YzqqWWmaPiC93Xum/8TDd5msa6P8AkL7/ADPM0D4uHGP+FhS+du+19MXO/wC25xdfat2t7Fze7r20b7\
fu2+I9Pm3/ANrb9uzxB4tm+0eZ/wAJ/Js2/aN/nedFs+1eb/aEHn/b9UnmWl7tLbXZfd31A5a10nwSn\
2PfpHhVdn9m+Zv0TSDt8r/hDfO35+H0udv2HUd2fOz9nnz9p3yf21leGLDwbNonhu4utO8MyzSaV4dm\
uZ59G0qWSST7J4He6lnkk+HkhlctZakZCwlLGCcsLkvJ/bXfWV7t+wf6fs2f2T/zFvL2eX/wgH/U/wA\
Plbfsn/TDy/sP/Lr9l/4kWP4RvdugeFD/AGht26P4WOf7X2bfLsvhzzn/AIWFH5e37J13RbPsXW2+y5\
0M5ltrbtfqtunQDAj0XwaEuwdG8MgvY6fHGDoulZaWLwnqdlMqZ8GNiQX80EbENCTM6MZ7lwNXtfym8\
fWfhI/8FaLG2hsPDn2eb4afsc4gj0nTEhk+0/Dv/g4FkXES+AIl+d20JhxDytof9GMMP9ifr/FdYjvh\
9rxv03Skx/aO3f5fgjWLXy8f8JgvmbfM8nZtm2eb9m+z23mf2Nd/lH8Qr3d/wVusv9P37/hp+x1/zFv\
M3+Z8OP8Ag4b/AOp/m83d9r/6b+Z9u/5evtX/ABPfD4icVhcFo/8Afst6/wDUbh/I8bPv9wo/9huW/w\
Dqywh+ol1pPgl/tmzSPCrb/wC0vL2aJpA3eb/wmXk7MfD6LG77dp23Hk4+0QY+zbI/7F+dP2p/gR8Ff\
j38FvF/wq+I3w60Xx54H8VePfh9e654S0qeHwnqeu6X4f8Ajb8J/GVvHpHiPStC0u40W7B8Myz20sN9\
pmxrJl8m1jeSz1P60vb3d9v/ANP37/7W/wCYt5m/zP8AhP8A/qf5vN3fa/8Apv5n27/l6+1f8T3H1O9\
2mR/7Q2bvHemzb/7X8vd5nxA+H8vn+b/wsKHzN32ff5vny7/s3m/b7nyPtume4lQm1Cvho4qhLSdKql\
OlUg9JU6kLLmpzXuzjdc0W1c+ly7H4rKswwOaYGtLD43La1LEUakJThKFWjONSnOM6coVISjOKkpQnG\
cWk4yi0mvxp+Nf/AASq/Y8+KvwE034H+G/gJ8V/hgngfQrqw+DHiHSPiq3iSy+E+q3Y8Ny3l1pHg/xL\
8WJrHUtC1C80KU63p7mKTVI70zfb7bV4hq7/AMmmqf8ABOv9rr4WfHHxr8IvCthYeHPjz8L9Ft/ix4F\
8Cv4y8T2Xjf4n6Jot3ca3c+N/2Zte0IxL4+1eyj0e51RLC0vovERGiX1vp+nS61pGtWcH+jzZXu37B/\
p+zZ/ZP/MW8vZ5f/CAf9T/AA+Vt+yf9MPL+w/8uv2X/iRfHn7Y/wCyX8Pv2vPhbYeH/EOsah4L+JXgG\
W28W/A/4z+FdQeLx/8ABz4g2lt8PZLHxD4aubXx0k82nvc6PYLqWmJ5Iu49GgkgOmarpGlaj4U+A4z4\
Ny3NcBiJ5Dw9g8JjJwtUw8OelTxPLyunUpVJVGsHmNBwi8LjYKKkk8Hjo18BVnSj/Z/0cPpa5z4cYif\
BvGuMeI4EzipOUMbUp18xxOSYmu71a3sateVbH5JjJN/2zk8KkZzUpZjlrpZpS/2v+Fj9lb9o79qP4Z\
SfEnVfhPpfw01PQotCm8U+MPgRF47/AGhPC2j3zaVpCWPjv41+A/Dfw9+KmhTza7YaTpNzfeIdP0/UR\
bWGk6jcavZeH4PDHhc3Pg396vht4Q/4Kb/GjwF4b+KHwy0n9h/xn4C8caY+r+HvEejftJ/t+raX1pcy\
atb3cTwS/H+KfSdTtr681W1u7K4it73Tb2yayure1u9PWG2+If2hv2dvip8QPil4uR9OPwv/AOCnfwj\
1PxB8RfF2g/D7VJNJ8M/tu6D4c1zxp4gl/at/Zb1zTdZtli+PVvPo91ea54a0eC3l8RyaRea3oFjZeL\
rHxH4bu/Lv2cv299W+C/h/xbP4G/aF+OP7LOp+PNSGteP/AIffBf8AZw+CPxx+DHirxbZaT4n064+Jn\
hPw/wDE743eG4PgzqWsWE8VtrGgaJpl1pfmafLcabd2ugnQ/BuhfjXA3ipg/DrF4jJeL+BMo4jymq5K\
jVxWCpU8RTqUFGnOEHicVhqdCtB8kMbl9evFUp8uJwkpQq3xX+kviX9HPKPHHhehxz4PvLqPHip5dPH\
UcdSzPOcLPDYjDwhh8T7bh7D4jH5hlmPo0p4vI+JMHluJWMjTxGX5phsHjMPio5V+rl78Cf8Agrgt3p\
Jk8D/sdxSS6wJYEtv2kf2944Lm6gttd1JYb6IftB4lsAZ7yTySPLZ4LaNkaKCKNM3xR+yz/wAFUfG3h\
bxD4I8XfCn9iXxD4S8W+H9T8K+JtA1X9or9vi703XPDutadbaRq+j6nBJ+0L/pVlc6ZbiCdGJ82Oa4D\
lvtVx53x9qP/AAVn+LUuo6LK3/BRj9reVrbxPb3STS/8E7v2O45reUT+MFF9Ci/tXOJtQVryZ0RpEHn\
aldMLqN0Fze3bb/grZ8W1+yY/4KN/tcx7f7P2+V/wTp/Y3/dbP+EQ2+Tj9q5PufZoPK/1f/ILsseTkf\
2d+oP6R/hTZc3hLkzUlovYZPor2t/yP+6bP54o/Qg+kjTqqpRhwfSq0JRalHIvFVSjJKMoyi1wjdNXT\
T0aauujf0N8FvgD/wAFp/A37JHxS8A/s73v/BOj4V+JLj4yftHeJ/DWteIx8Zvit8XbfxVf/tEa14n8\
TyaV4r+Nvh3xvpHiF9U1m01mC3m8XSalIY5b5r6e2kuo7qb5Dvv+CVX/AAVn/bk8F/DKf/goZ8Tf2P8\
Aw1qHhb4neFZoPjf4b8D293+01J8NL7RPDZ0P4cJ4b+Cfhbwv4E8bfDqL4g/Z7pm1y5tfFWn6rqGr39\
lq9xpl5dWGq878D/8AgrH8WLLwhexQ/wDBRH9q7T1PxX+NN0IdO/4J4fsd3ESyXXxy1a9e6R5P2orQi\
6klEc7IEVY57O2jSZlVLiy8X+Nn/BTD9oPxR4r/AGaotB/bv/af1jQ9B+JXwkn8UNffBD4bfAq30+wt\
vGHwxjtreTwL8I/jXq2l/HqAWdvqUFvp3i6aysI44Vsc2+n69rS2v3Xh99JzD4TjzhjLeHuH8LQzzF1\
aOQ0YTpZM8NTrZjUw+WLGaY3EY2FTBJuph5unONB806mH1m4/i+A+gd9IrNuBsm45q8Y8P8G5vV4ZWP\
8Ar+Bynj/DydWGTSxThWeYcK4bCYuOMm40MRTxWKq/WacnShDEzqKhiPVP2zv+CBHxK/Zz+D+u/E/4c\
fHbT/j9pvh+w1ubxloumfCzVvBGu6BpUNpfGy8SWtrc+MdTTV/DayWedUn8yCfSbfVLO+ltZ7GLWrnR\
fw8k+Fk/hXw3441C+0TxJ4f1Hw3rfhG30GHWtf8AAmqad408KarovjjV/FWuW19beIbR/C93oWqaN4e\
tI9Ne1vZ9b/4S+5vYZbJdMa3u/vD9tz4tzfEL4n6z420X44fHDxz4/wDFXj3xzeeM/Gvjnw34e8OprP\
hhvCHw1uPArL4L8JePtf8A+EZ1dPEmr/Fe0liGrXWlR6NpWgQaYluqXNlX55+L/Fum+P8AQ/Etr8XfG\
2nWOn+H9D8TaPpiatZ+LdMvNV1S4+G2ra7/AMIRqdxp2iXsw13XdX0qaw0rUY7dtMjn8SWtzqWsWlr9\
surb7rxD8fuBeDeOeJcqzzAcS5344eGEsVkOAxmCw+S4PKMVKvmeFhjJY+jmGGzDFYeVGNOvHBYnCUM\
txdXCyWCzLCZdWxGKrUv9HeGPBbNeFfCXBU/EfjaGbZ9iKsswrZisuoZB7Slh8sxWNngMTDFyzDGSwl\
KbvCtgsjynMsZCnhIPBynHE83FfFbxjfeMtP8AB3irwToOlaZ8a/A8EOm3esi/gu9M+NHhy3/tkx2nx\
MsLrxW6SeJrLTrrSrGzvLFLW1uLLw1p4v7YalBJrcpXLeFNI+HNv8WLl9b0ax8c+Ffh/H8NrXwhr3gn\
WtWmsrHXNb8E+F9b+K3gy7n1G80ceK9c0jUdai0aXULY/wBlyT6Tcz6Vc6pp91Z60pTy3NvB/wCk/jc\
w4o+kx4i4DhTjXhung8vwss6x2GhiMRgFho1aFKnWwuT4irXpYJSVFrEVmqFWVShQpxhB1K3xnBHh94\
k8RYPN+J/C7xhzDw1yXPsxxs69LKcfjqNPNsZh67wmJz3FYXG5Bi4UsTj69CpGGIoOLzLAYfBZjiv9p\
xNSFP8A1qr2bX2/tDHiLR23/wBr4zDey7/M/wCFhYz/AMXhl87d9sjz/rvM+1n/AI+ftg/tvL8U3Gtf\
2L4nafX9LmgOl+J2mSL7Wks0T2nxILpHcP8AF6cCR0vFAcrcBjeFit2LvGt9Ze/23/p/m/8AUW87/ko\
P/U//AGn/AI/P+4x/r/8At6/5jtY/i7+3P7A8V7/vf2P4p8z/AJKJ1+xfEb7R/wAfHzdf7Y/1vP8Az8\
8/27XzsXaUfJroj/AQLabX1vrtz4i0dQ3iXUZw3k3qFlfxF4QmExl/4XDH5jFbZ387zpN5txN9vn+zm\
+0wsptfX+z8+ItHXZ/ZGcQ3sWzy/wDhXucf8Xhi8nb9jkx/qfL+yD/j2+xn+xNi2/tv7bd7P9b/AMJH\
qHmf8lB/4/f+Eg8Jed/x7/vv+Pz+zv8AW/8AEw/57/6f/ZVFl/bf+geV/wBQnyf+Sg/9SB9m/wCPP/u\
D/wCo/wC3X/mBUrgcnoVxrQu7wR6/pcbxapoS3Bf7XtMsei/CVt8KL8XoDYxrBaouxjGUexMm61FuF0\
J1m/iBdHhjOv6MpGm3KeWLO9jALWvj1Qn2f/haUW0E3aDZ9lXd9rK+RJ9rEes6Xh/+3PtupeX0/tjQv\
I/5KJ0/sD4R/Z/+PXj739kf8e3H/Pr839h1PZ/2p/ZEPlf8e39m3O3/AJHH/UfZfHe//j0/0T/V/wBr\
fc/0f/np+7/turb91vty/k/8vz7sDE1241o3dmJNf0uR5dU11bcp9r2iWTRfi02+ZG+L05vo2gunXYp\
kLvfCTddC4K67qXM2vtfWjjxFo7BfEunzlvJvXKqniLxfMZvN/wCFwyeWwW5R/O86PYbgzfb4PtAvtT\
PEH9ufbdN8zp/bGu+f/wAlE6f2B8XPtH/H1x97+1/+Pnj/AJ+vm/tyti5/tv7bab/9b/wken+X/wAlB\
/4/f+Eg8W+T/wAfH77/AI/P7R/1X/Ew/wCeH+n/ANq1F3ptp5L+n8wMeym19f7Pz4i0ddn9kZxDexbP\
L/4V7nH/ABeGLydv2OTH+p8v7IP+Pb7Gf7Ey/C1xrX9i+GGg1/S4YBpfhhoUl+1vLDElp8NyiSXCfF6\
AGREs2BcLbhTZhgtoLTGidZZf23/oHlf9Qnyf+Sg/9SB9m/48/wDuD/6j/t1/5gVY/hH+3P7A8KbPvf\
2P4W8v/konX7F8Ofs//Hv83X+x/wDVc/8APtz/AGFRd2tp9y/r/PqBmxP4gEd8P7f0Yb9N0lAPsd6u8\
x+BdZtChH/C0l80K8oi2bZvLEhtfItjJ/ZF1+VfxBuNXb/grRaK2uadJcP8NP2PvLlDXLwnzfh3/wAH\
Cpi3wH4rztcZS6uA2JJfOOpIw88TsviH9bYv7U8u+2/d/s3SvN/5HH/Uf8IRrH2f/VfL/wAgr7T/AK7\
/AEf/AJ9f+JL9rr8o/iF/bf8Aw9usvN/6Jp+x153/ACUH/onH/Bw39p/4/P8AuMf6/wD7ev8AmO14fE\
bthcF/2HZb/wCpuHPGz7/cKP8A2G5b/wCrLCH6q3s2vt/aGPEWjtv/ALXxmG9l3+Z/wsLGf+Lwy+du+\
2R5/wBd5n2s/wDHz9sH9t5d9ca1G80k+v6W0b+OLSVTF9rtXLy+PPAMlvctcP8AF5RMnmwLK8nmyGdb\
UsuoSmH+0NL6y9/tv/T/ADf+ot53/JQf+p/+0/8AH5/3GP8AX/8Ab1/zHax9T/tzMnlf67/hO9N8z/k\
on/H5/wALA+H/ANo/48/3/wDx9/2f/rf9P/5+f9N/suvdi7Sj5NdEeyFlNr6/2fnxFo67P7IziG9i2e\
X/AMK9zj/i8MXk7fscmP8AU+X9kH/Ht9jP9iZt4/iBtHmjGv6MxOm2yeWbO9kBK2vgJSn2f/haUu4A2\
jjZ9lbb9kC+RH9kMejdVZf23/oHlf8AUJ8n/koP/UgfZv8Ajz/7g/8AqP8At1/5gVZ15/an9kTeb/x7\
f2bbbv8Akcf9R9l8CbP+Pv8A0T/V/wBk/f8A9H/55/u/7Eoh8UfVAfIH7Tn7JPw8/a98I6Tpfj7XtQ8\
N+KPh74+13xl8L/i18PtTTRfi78MvFGneMvHOr3moeBfGVx8SdQGmwaheaZpn2m3e2vY3MdjeRLLrNp\
pGp3nz/wCKP+CXPw88U674l8U+Jvi+vifxN4i1bxDr/iDxF4g/ZZ/4Jx63rviLXdUvPGeo6nrWt6ve/\
s53Fxq+rXuoJHPc3MslxNczarJKXuXuLZtU/TjT/wC3PsWred1/tjxx5v8AyUTp/b/xS8//AI/+fu/2\
v/ruP+fj5f7crYvf7b/0/wA3/qLed/yUH/qf/tP/AB+f9xj/AF//AG9f8x2vnsfwvkOZ4qtjcZlsJ4r\
EcntJxlUpOp7NONN1FSnBTlCLcIyknKMPcTUUkv1Thjxt8UuDsmwPD/D/ABdVwuTZXLESwtCrQwmMhh\
Fi506uKhhXjMPiJYajiK1KFetQoSp0aldOvKDrSnOX5E6n/wAEoPg3DqWgwt8QtLk+1eKYLOOVP2T/A\
PgmzEsKFvGTSXcqx/s2ulygtLCNgHkSBHvRcPdxRfZ7q+0Lb/gk18Hm+y7viLo6b/7P34/ZI/4Jrrs8\
z/hE/Mx5n7Nsezb9svMb/L2/YR5nkeTd/wBmfqdrn9uf214T3/63/hO7bZ/yUT/j8z8SfJ/1377/AI/\
v7Q+5/p//AD7/APEx/tOtiy/tv/QPK/6hPk/8lB/6kD7N/wAef/cH/wBR/wBuv/MCrj/1I4X0/wCEvb\
/p9iP/AJafRL6S/jar2423/wCpdlPkv+gDyR+HfwI/4JS/CG/8GX80vj/SbU/8Le+OVoyN+yX/AME4W\
KrafHrXbEzBtQ/ZktnjVke6kVSqRRi2VUkEEE82n/MX7TP/AARl1bxf4u/ZL8b/AAi8bfCl/BHw/wDi\
b8K/EfxUt/G3wx/Z6+HviH/hH77xl8I9Wt4fCegfAf8AZ+sdI+K+qQWOjeJSbXxql3paXdtYWc1tb22\
q6xYT/vNovwR8aaL9pg8I/Hb4ueE9J1fxNrviy30LR9I8EXOnaZqnjzxTo/jLVRp82q/BO+vJIDr/AI\
qspo991cyD7FAsMkudLNz59qXw1+IkfgfQ5rj9oL4vXEBufhAJbSXRfhatuv22TSH0lg0vwRRt1npxm\
S28+QoyjMQurD7QxeTcI5NQzLJK6yKrLHYDF4HExqRq05p4jC4qhXhJ08RiJUqkJVaacqdak6c43jUh\
Z2Py3J/pcfSP4E4Gjgfq2Nx2KyDh3FZZKbwfCU8JNSyatltarTX1uhiHBQnOpRlOFOqmoSnS5lKm/wA\
TvjH4S+KH/BOb4jfEDwb8SdO034//ALAv7TPiHXP+El8Pf2Jpel6Va6rfz+JJorvTfD3gvxhYaX8OPj\
NosMC3Wkrpb6ZpOvWGi20+ltYS2Ns3h/8Ak0m1/wCNfgzUf2jdmiyro40iwvPEXxMtNU+J1tr/AIF+F\
/ifwj4u+EPxR0DW9d8P+N7LRNA+GHiu8+K2m6ZrNxqKahJfzapYWVrqtrba3qWm63/pNfEz9mfX/ir4\
L8WfDv4mfHH4s+MvBfiay1Cw8SaBrPhz4ava6hFbz+K7w3Cyv8BI5dP1OHUNK1W7tbyOS3u7C8n+2RT\
2t1bX01n/AAL6d+zD+3R8UrM6vpH7Pn7bVh4N8f8AhG98a+FfB3jz4XaL4v16/wDAVxLrtzYx6nNon7\
GX2DxFIumylbi/isrSyae58yRLJpfs8P7j4sZ14V/SF4c4WpeKvHOJ8HfErh363GGNhlNbNcl4hX1bC\
8mNxWEy+slk+c4f+z8Fhq2bQg4ywj5KdCvP6rRwH+sH0PvpL/8AEX+H+KMn4m8P834U8RcDPLMRm2Po\
47h/DZRxHQw2X5plNCrj8tfEmGw0sXWweMlQzejShTpZhSwGWSqyng8Ksuo/j98NfEPxo8dfHfx94p0\
zw7q3xesNO8AaBdXvh7UNX1XxN4v1P4GfA/wzZ+E9D174cTahPd3N/wCFvCXwt+H7iJUkuNL0Xw74Yb\
TvNiNpZNEV9z+KP2Q/jD8QPBnwu8UeK/C/j++8DfFTx9Z/BL9nfUdR+HXhC28HeKPiT4oEPh3TPBHw0\
1G0/ZYNl428dXd5o1varpfh+4bW72XwhLDDZyi0iWIr8r8NoeCeHwuZ4vP8i4P8T4Y6WH+pYrOMzq5H\
jaeDoYeNClKpQxmBxkKqxbhLE05QxMsRToTo08dRwtdLD0/054D6RHhC8Twf4T8YVcLk8MZmGMxtDHL\
ghewzLH4/EYzGUcPgsRisZPLKFCtWeH+pQxdWh7ShPFQhQq4qvSj/AKhF7qFkn9of8SnWE2f2v08D6+\
mzyv8AhYWcY+FsPl7fsDY/1Gz7EMfZfs6/2Hl+Kbq0l0XxPAmlaojvpfieJTL4M1q1ijYWnxIQGSaf4\
Wwx2samyOWfyEiFkC32UWw/sPrL2y2/b/8AQNmz+1v+YT5ezy/+E/8A+pAh8rb9k/6YeX9h/wCXX7L/\
AMSLH8XWW3QPFY/s/bt0fxSMf2Rs2+XZfEbjH/CvY/L2/ZOm2LZ9i6W32XGh98bc0brS6/rY/wALQtt\
QsmvrtP7J1htviXUbfZ/wg+vsFMfiLwhb+R5Z+FsmxVN0E8ryYgouTH9ggExsdULLULJ/7P8A+JTrD7\
/7I6+B9fff5v8Awr3Gc/C2bzN329c/6/f9tOftX2hv7c2Lay3Xt2v2Ddt8R6hDs/snft2eIPCUP2fy/\
wDhAJNm37Rs8nyYtn2ryv7Pg8/7BqhZWW77B/oG/f8A2T/zCfM3+Z/wgH/UgTebu+1/9N/M+3f8vX2r\
/ierQDk9CurQXd47aVqji71TQpY9ngzWp2ZZNF+EsGJkj+FsxSRnuD8snnPIl6H/ANKjux/bjrPVLJ9\
Hhl/s3WWB025k80+DPEDk7bXx63mecfh5KWI+wk7vtTkfYwftEf2dZNF0vD9luvdS/wCJfu8zWNCP/I\
I3+Z5mgfCMZz/wr2Xzt32vrm53/bcZuvtW3W57O13aRDJ9k35025fzf7O8zO218dt5nn/8IfLux9kzv\
+1Pj7Fu+0R/ZvM0S3blfb3fyf8Awfw7ahia7dWhu7N10rVEFpqmuyyb/BmtQMqx6L8WoMQpJ8LYS8iv\
bj5Y/JeNLIv/AKLHaH+w9S51CyW+tE/snWF3eJdPt9n/AAg+vqGMniLxfb+QYx8LY96sbUp5XkyhhbC\
P7BOIRY6WeILLbe6b/wAS/b5esa6f+QRs8vy9A+Lgzn/hXsXk7fsnXNts+xYza/ZduibFzZbb20X7Bt\
3eI9Ph2f2Ts3b/ABB4th+z+X/wgEe/d9n2eT5Mu/7L5X9nz+R9g0uNNNH56/8AA0/EDHstQsn/ALP/A\
OJTrD7/AOyOvgfX33+b/wAK9xnPwtm8zd9vXP8Ar9/205+1faG/tzL8LXVpFovhiB9K1R3TS/DETGLw\
ZrV1FIxtPhuhMc0Hwtmjuo2N6MMnnpKL0lftQuT/AG51llZbvsH+gb9/9k/8wnzN/mf8IB/1IE3m7vt\
f/TfzPt3/AC9fav8Aie4/hGy3aB4UH9n7t2j+Fhj+yN+7zLL4c8Y/4V7J5m77X02y7/tvS5+1Y1w0ts\
7+v39P68wM2LVLIx3x/s3WTs03SZM/8IZ4gOzzfAus3okB/wCFeN5ZYQmbduhLmITm4uWQaxaflX8Qb\
i2H/BWi0nGl6iiQ/DT9j7Knwjq8My/Zvh3/AMHCqNstm+GUMg2mJNu1YcCwdk+zLYyHQP1titcx3x+y\
Z2abpT5/s7ds8zwRrF15mf8AhD28vd5fnb90O/yvtP2i58v+2bT8o/iFZbf+Ct1l/oGzZ8NP2Ov+YT5\
ezy/hx/wcN/8AUgQ+Vt+yf9MPL+w/8uv2X/iReHxHb6rgr/8AQdlv/qbhzxs+/wBwo/8AYblv/qywh+\
qt7qFkn9of8SnWE2f2v08D6+mzyv8AhYWcY+FsPl7fsDY/1Gz7EMfZfs6/2Hl311aXDzQppWqFo/HFo\
hWXwZrSIotPHngHzLdRP8LZFDhZjGkAhiYtciCPT4HuBY6p1l7Zbft/+gbNn9rf8wny9nl/8J//ANSB\
D5W37J/0w8v7D/y6/Zf+JFj6nZbjIn9n79vjvTYdn9keZt8v4gfD+LyPK/4V7N5e37Rs8ryItn2nyvs\
Ft5/2LU/djbmjdaXX9bHshZahZP8A2f8A8SnWH3/2R18D6++/zf8AhXuM5+Fs3mbvt65/1+/7ac/avt\
Df25m3mqWSaPNL/ZusqBpttJ5o8GeIEI3WvgJvM84fDyIqT9uB3fakJ+2E/aJPtDSa11VlZbvsH+gb9\
/8AZP8AzCfM3+Z/wgH/AFIE3m7vtf8A038z7d/y9fav+J7nXlrt0iaT7Jsxpts/m/2d5eN1r4EbzPP/\
AOEPi25+153/AGpM/bd32iT7T5mtkPij6oDEtbq0trTVUfStUUrqnjOX914M1plRW1r4pToC8HwtiEU\
iJa/Mv7h4Xstj/ZZLX/iR6l7qFkn9of8AEp1hNn9r9PA+vps8r/hYWcY+FsPl7fsDY/1Gz7EMfZfs6/\
2GafZbLLVv+Jfs2ax44P8AyCPK2bNf+KRzj/hXsHlbfsnXEOz7FnNv9l3aHsXtlt+3/wCgbNn9rf8AM\
J8vZ5f/AAn/AP1IEPlbfsn/AEw8v7D/AMuv2X/iRJ2u7Jpev/AA5PWbq0bWfDG3StUUReOLRHR/BmtQ\
s4luPiNYC3ihk+FsZuXaSNUMCQysUtWB0+eO2ax0vUstQsn/ALP/AOJTrD7/AOyOvgfX33+b/wAK9xn\
Pwtm8zd9vXP8Ar9/205+1faG/tw1yyxrXhNf7Pxnx3bQ7P7I253n4kweR5f8Awr1N277P5fleU+/7N5\
P2C48j+z9M2LKy3fYP9A37/wCyf+YT5m/zP+EA/wCpAm83d9r/AOm/mfbv+Xr7V/xPTTTR+ev/AANPx\
Ax7LULJ/wCz/wDiU6w+/wDsjr4H199/m/8ACvcZz8LZvM3fb1z/AK/f9tOftX2hv7c8k13UbS28CaPE\
9hqoe2v/AIIxu8PhTW5IlaT+yZy0VzB4HjR45PKMgeOWNZ9gmD6hgalB7nZWW77B/oG/f/ZP/MJ8zf5\
n/CAf9SBN5u77X/038z7d/wAvX2r/AInvkOsW+34f6Efs2zZd/A85+w+Xs87+x587v+EXh8rzNnmZ3w\
+bs87OobP7Sg9DKrf2jgdNfbUfu9rDy/rszwOK/wDkl+JP+xfjP/UeoejXuoWSf2h/xKdYTZ/a/TwPr\
6bPK/4WFnGPhbD5e37A2P8AUbPsQx9l+zr/AGH/AC6/DLwrqkP7PXw78QS/tLftG+DvCqfsmaHq918c\
dJ/ZT/4LM3ll8PdKsfBGpXv/AAkGna7pX7QcHhK60pdN0jUdXg1S00aPwOU8IiYaVaaZDJa2X9D/AO2\
H8Ttf/Z//AGU/2qvjt4U0LSNR8U/BL9nv4/fFvw3pmv6BeXGhX2v/AA0+HHxk8Y6PY63Z6d4S0y4m0h\
9R8N20dzHBeabN5Nq6xXOnPbLLoH8fP7L37QeteJ/hn8L/ABH4u/ZZ/wCCRmny3f7Kmgar4LW88Pfsc\
axqXi3xLqWgadf6SnxY0zxl+1z4Yn8G65O1zL/aOp3EV3r+jSNNHH4ZkdJV0v8AGvEnEUsLWyatiMre\
Pozo5hSjKVPGyhCpUp0JRd8DUo1E1GnJtyqxgvd5lK5/oB9C/KM1zrG8dYbJ+K3w1iMN/ZeKqKFbIqU\
sRRoPH0pQ5c8weMhUfPi6ahCjSnGzqTxVGtQpuK/Lj9tzUvixP/wTV/Z68NfDyz+JPxw8C+KPjl8SYf\
HUbeBf2po/C37L3xB8L6PZ33w88A+DtWHi+L4c+JPEvibRPGfiXxgLnRdEXxFozTX1hrd5c6b4h8m8K\
/Yb9pD9kH4Kfs8ftc+NfhJF8Of2frj4Hjx14R1/QPEXxE/aL8N3nxt8MWHjP4S+B/FifDuT4W6n+2f8\
KZW+H0Pi7VL6KzvfEMdpq66PqMWpSeJfEEZsZ9XK+H4K8UPFjwuyb/VjhWpDIqOCrToYlUc14hwccTi\
cIoYaWJcYSpUKvtIU4KNWgnTcVGEeVQjTh/b3i19H3wE+kPxPS8XeKPE7ivFUeO8LSzjLaODyjhGosv\
y7N5SzKjl1WWGxkatOrhJ4mpGeHx0p46nOU6uKlUq15Yiv/ZzdRRj7Xi+018f2jjZpXgiPft/4TDHl/\
ZdYby93lx7PJ37Pttv9m8z7No32vG8WRRjw/wCKMX2mtjRvEmCuk+BUDYsvG+Cgg1kqgby49nlFgn2y\
3+zlxbaN9r0r3T7J/wC0P+JtrD7/AO1+njjX33+b/wALCzjHxSm8zd9vbH+v3/bRj7V9oX+3MvxTa2k\
Wi+J501XVHdNL8TyqJfGetXUUjG0+JDgSQz/FKaO6jY3pyr+ekovQG+1C5H9uf0hGV2k7JN/yo/xANu\
CKM3VwDfaaoGtXih20rwQ6Mo1jw6onSOfWFiS2ZXd1ijZrFY7aaKGZ7KfUprctYoz9kzfaamf7Ozv0r\
wRJs3f8IfnzPtWsL5m3zJN/nbN/2K4+0+X9p1n7JBbafZLfXb/2trC7vEuo3G//AITjX1DGTxF4QuPP\
8w/FKPerG1D+b50oYWxk+3ziE32lllp9kn9n/wDE21hNn9kdfHGvps8r/hXuM5+KUPl7fsC5/wBRs+x\
HP2X7O39hrm9P/AUBm6FFGb3V832mrnWdHzv0nwK/l7vD/wAMsiU3GsqZivmPv+0bC4s7gXAjW51g2t\
u2jQ6dGxurJT9imPlPYeFnmBEHiwhGnudSW5aQmNAHaMTg3kBRGkttIW6paFa2hu7xG1XVEFpqmhRR7\
PGetQMqx6L8JZ8zPH8UoS8ivbn5pPJeNLIJ/osdoP7DdZ6XZJo8MX9payoGm3MflHxn4gQjda+PV8vy\
T8Q4ipP24jb9lQn7YB9nk+0LHrVOWjta3u9F2/4f+noBrsUYvdIxfaa2NZ1jGzSfAqeZt8P/ABNwIjb\
6yxhLeWmz7PvKC8txbiRbbRzdbM8UYurcC+01gdas1LrpXghEVTrHiJTO8cGsNE9sqojtFIy2LR3MMU\
0yWUGmzXGJrtraC7s0XVdUcXeqa7FJv8Z61OzLJovxanzC8nxSmKSM9wPmj855EvSn+lR3Z/tzUudPs\
mvrR/7W1htviXT7jf8A8Jxr7BTH4i8X3HnmQfFKTYqm6L+b50QUXIk+3wCYX2qTzbW67+6vw+Xpr94E\
9rFGfsmb7TUz/Z2d+leCJNm7/hD8+Z9q1hfM2+ZJv87Zv+xXH2ny/tOs/ZMbwnFGfD/hfN9pq50bw3k\
tpPgVwubLwRkuJ9ZCuF8yTf5pUP8AY7j7QUFzrP2TSstPsk/s/wD4m2sJs/sjr4419Nnlf8K9xnPxSh\
8vb9gXP+o2fYjn7L9nb+w8vwta2kui+GJ31XVEd9L8MSsIvGetWsUbC0+G7kRwwfFKGO1jU2QwqeQkQ\
siF+yi2P9hnN16/4Vbz/wCBp9wF2ONNl1/pVkMWWnkA2HhYlyfC2pSFEMmpBo5FdRE7xBp3nlS4uEj1\
aO1tZPyg8fxRj/grdp2L7TXx8NP2NcbNK8ER79vw4/4OC8eX9l1hvL3eXHs8nfs+22/2bzPs2jfa/wB\
VItLshHfD+0tZG/TdJjx/wmfiAb/K8C6zZCMD/hYa+YVExh27ZihlEBt7ZnGj3f5V/EG3tj/wVotIBq\
mouk3w0/Y+yx8XavNM32n4d/8ABwq7bLlvibNIdxlTbtabIv3VPtK30g1/w+IpP6rgr2/37Leif/Mbh\
zxs+/3Cj/2G5b/6ssIfrbdRRj7Xi+018f2jjZpXgiPft/4TDHl/ZdYby93lx7PJ37Pttv8AZvM+zaN9\
rxtWijKEG+01APGekKHfSfAskbKPHPgpRMkd1rKwpbsrs6RRO1kkdvLHbzPaTajLBpXun2T/ANof8Tb\
WH3/2v08ca++/zf8AhYWcY+KU3mbvt7Y/1+/7aMfavtC/25l31raW7zTJquqBpPHFo5aXxnrTowu/Hn\
gHzLhTP8Uo1LlYTIk4mlYNbCePUJ3txfaX7sZXaTsk3/Kj2TbtYoz9kzfaamf7Ozv0rwRJs3f8IfnzP\
tWsL5m3zJN/nbN/2K4+0+X9p1n7JRuY0GnSMLqyY/YoT5SWHhZJiTB4TJQT22pNcrIDI4LrGZybOcui\
yXOrraz2Wn2Sf2f/AMTbWE2f2R18ca+mzyv+Fe4zn4pQ+Xt+wLn/AFGz7Ec/Zfs7f2Hm3ml2T6PNF/a\
WssDpttH5Q8Z+IHJ22vgJfL8kfEOUsR9hA2/ZXI+xkfZ4/s7R6KRk+aO266L/ACANLijFlqWL7TXxrP\
jPHl6T4Fi348QfEPAjFlrLiMt5abfJ3FDeW5gDtbaOLvZuoox9rxfaa+P7Rxs0rwRHv2/8Jhjy/susN\
5e7y49nk79n223+zeZ9m0b7XiWtraXNpqrvquqMW1TxnF+68Z60quq618UoEJSD4pSiWR0uvmb9+8z3\
u9/tUl1/xPNS90+yf+0P+JtrD7/7X6eONfff5v8AwsLOMfFKbzN329sf6/f9tGPtX2hf7cXNbRapd4q\
/6/mBm61FGNX8Kj7dppB8ZxLuXSfAqoFNv4/QzNHFrJia3VUWRonYWTRXEUU8yWMOnzT7NrFGfsmb7T\
Uz/Z2d+leCJNm7/hD8+Z9q1hfM2+ZJv87Zv+xXH2ny/tOs/ZMTWbW0XWfDG3VdUYS+OLR3d/GetTMgi\
uPiNfi4imk+KUhtnWSRXM6TRMEumJ1CCO5a+1TUstPsk/s//ibawmz+yOvjjX02eV/wr3Gc/FKHy9v2\
Bc/6jZ9iOfsv2dv7DOba3Xf3V+Hy9NfvAntYoz9kzfaamf7Ozv0rwRJs3f8ACH58z7VrC+Zt8yTf52z\
f9iuPtPl/adZ+yeT6oiDwD4fxc2j4vPgvgJZeHI2fddaG7CNrW/ZoyjARyeSGMsrrNfCG/WGB/UbLT7\
JP7P8A+JtrCbP7I6+ONfTZ5X/CvcZz8UofL2/YFz/qNn2I5+y/Z2/sPyTXdOtLnwJo8r3+ql7m/wDgj\
I6Q+K9bjiZo/wCyYCsVtB44kRI4/NMYSOKRYN4hCafkabP35W75jge/tqPRbe1hf59vvujwOK1fhbiV\
PZ5fjP8A1HqHW/FP4beCfi78OviT8J/iJZ6X4m+H3xP8FeOvh3458PeR4a0lPEPg3xpoXj7w14m0Yaj\
4c8SQ3mlreaJfXUCz6fcRXNsNUt5NPmEtpoj3P5R+FP8AgkfZfDPwlr3wY+Gv7f37bNl8Kn+BE3wGn+\
H3j7xn8Bfi34Ti+Et7o/jPwfbeE/Deg+LvBNzbeEhb+GfDdrZWOoabCuqWEGrsmk38Qa0Gp/sVe6fZP\
/aH/E21h9/9r9PHGvvv83/hYWcY+KU3mbvt7Y/1+/7aMfavtC/25l3FraSa1r8B1XVGQaX5oK+M9aaV\
2vLv4vI4eZfilLJcRsJ12K3npm9Yx/aTeN/bnhYvLsBj506mNwsMRLDqSjzRTXvrlknG6jJOLklzKVr\
u1uZs/TOFeOeKuCauJrcM5r/Zs8Z7N1P3OHrqXspc9P3cRRrRXLO01ZL34U5u8qVNx/Bz9qTSPhr8Iv\
ite/Cz4x/8FLf2z/ht4o+Klx4O/aO8R6f8EPh18E/h5JrwtvDHgb4CRX6fEvwL8P7Wfcnhv4f2NtdaH\
NqMlmlxottrWo6Sl3e3t1bFe4fHb4i/tZ6V/wAFFr/4U/sfeCPgl4l8WS/sR/B34i+JPFP7Rv7Rnj7w\
P4cs9G0v4wfELQ7Dwx4b8KeBPFV74g13WJ/E9n4cF3qkUcOjaFZhv7TNpfTaRb2JXweZ5Y8yryqUaGU\
R9jOvTlGrk+a4urGUcRUSdTFYbPMHRq1KsOTET5aMXTlWcKn7yMm/6Bw3jHxnwxk/DuCp4nF4WNXAYS\
olRzPJ8rhKPsacKTjg1lSqQoxw8aNKhOo6inTpr2dRxjyx/Z+9vd32/wD0/fv/ALW/5i3mb/M/4T//A\
Kn+bzd32v8A6b+Z9u/5evtX/E9x/F17u0DxWf7Q3btH8UnP9r793mWXxG5z/wALCk8zd9r67pd/23rc\
/as64XsOvr/aGPDujrs/tfGZr2LZ5f8AwsLGf+LPReTt+xx5/wBT5f2Q/wDHt9jH9iZfim31r+xfE6z\
6BpcMA0vxOszxfa3lhiS0+JAd47d/hDADIiWakIWtwpsypa0FpnRP0mKvKPm11R/KJ1lte7b27b7ft3\
eI9Qm3/wBrbN2/xB4Sm+0eZ/wn8e/d9n3+d50u/wCy+b/aE/kfb9LLK92/YP8AT9mz+yf+Yt5ezy/+E\
A/6n+Hytv2T/ph5f2H/AJdfsv8AxIse2h19r67Q+HdHYL4l1GAL5165VU8ReEIRCYv+FPSeWwW5dPJ8\
mPYbgQ/YIPtBsdTLKHX2/s/Ph3R23/2RnE17Lv8AM/4V7nH/ABZ6Xzt32yTH+u8z7WP+Pn7Yf7bVgDw\
/e7b3Uv8AiYbfL1jQh/yF9nl+XoHwjOMf8LCi8nb9k6Yttn2LOLX7Lu0SezutukQx/a9mNNuU8r+0fL\
xutfHa+X5H/CYRbc/a8bPsqZ+27fs8n2ny9bxNCt9aN3eGPQNLkeXVNCa4D/a9olk0X4SrshdfhDOb6\
NoLpG3sJC73xj23QuA2uus08QNo8Mh0DRmJ025fzBeXsgJW18esH+0f8Ktl3AG0Q7/tTbfshbz4/sgk\
0a2vda78v5P/AD/PswNLxBe7r3Tf+Jhu8zWNdH/IX3+Z5mgfFw4x/wALCl87d9r6Yud/23OLr7Vu1vY\
ub3de2jfb923xHp82/wDtbft2eIPFs32jzP8AhP5Nm37Rv87zotn2rzf7Qg8/7fqnJ67b60LuzMmgaX\
G8Wqa61uE+17TLHovxaXZM7fCGA2MawWrtvURlHsRHttRbltC1LmHX1vrRB4d0dQ3iXT4CvnXqFlfxF\
4vhMPlf8Kej8xitsieT5Mm825h+wT/ZxY6ZFnptr5r+l8wNiyvdv2D/AE/Zs/sn/mLeXs8v/hAP+p/h\
8rb9k/6YeX9h/wCXX7L/AMSLH8I3u3QPCh/tDbt0fwsc/wBr7Nvl2Xw55z/wsKPy9v2Trui2fYutt9l\
zofzL+x/4t/a68c/Cix1H9rb4A+B/g/8AF2z8V3OkzaL4U8Rafrvh7xL4YEnw0vfD3irTLXQvDPisaI\
s1rrdxYS2dzrWpXNxcaTLqJRINbgsNR+hvC1vrX9i+GFg0DS5oDpfhhYXl+1pLNE9p8NwjyW6fCGcCR\
0vGJQNcBjeBQ12LvOt8mBxUcwwWHxtOjVw8MTGMlTr050K0OZfDUo1FGpCUXpJNaPZtNN+3xLkVfhjP\
834exOYYHNq2UV6lB4rLcbh8xwGI5HZVsJjcJUqYfE0KitOnUhPZ2nGE1KEduK6xHfD7XjfpulJj+0d\
u/wAvwRrFr5eP+EwXzNvmeTs2zbPN+zfZ7bzP7Gu/yP8Ai94p0Xw3/wAFVLrxL4l8T6XoPh3QfhB+yV\
rmv6/rnia003RdG0XTfhd/wcQ3+q6xrGq3/wARWgsdLgsZJ5ri4mkkiSKd5JHuEuGbXP1XiTxAY74/2\
Box2abpLg/bL1thk8C6zdlyf+FWt5QZ4hLv3Q+YIzdefcmP+17X8C/+Cj9vqy/tLftZM+h6dHOn7Cnw\
82xqlyIlEX7Mn/ByCIi0x+FMBgIjtbgtiOHyW01FBtxAzeHvI4rqujllGulzOjisvlZ6X5cXh3b52Ph\
OJ6rw+USrpczo4nL5pd3HMMK7fOx+t97+3/8AsNN9v/4zd/ZQff8A2t/zdB8IJN/mf8J//wBVwm83d9\
r/AOm/mfbv+Xr7V/xPfUfAvxv+Efxp0XVfE/wa+MXw5+LHh3SfitZ6Bq/iL4ZfE/wz450XTfEcXi74V\
69caNqOs+FfitLBa62NH1TRb54pbp5zbX9reNd3ERiv9O/nl/4Jm+BP2dvjp+wX4S+LPxA+L/xT8P8A\
xF+AmgfGPwToXxG8eftMeLdI8S/snXOvfATSfA/j5PhBf2vgK00jQ/Ai+BtL8FaxpFrc2+o23hf+35N\
Pt743lnfanb/f/wDwSu1z4heMfhV8btc8deDbnS9eu/2j/gvayv4h+Kug/HzxD4g0/Sf2R/8Agnjo/h\
DxprHxY8HfDS+0z4gX/ibw1DoWvXWoWsjASeM5I2tGmd7XWPH4e4mzDNKuTSxNPDvDZ7S9tQdD2kuWC\
pKcnWm5ShTqKpzU40pa1IJ1Yz5qWIo0f6q8TPCPhnhGjx3h8mxmaLNfDjHxy/MYZnHCUPaYipja2Hpr\
A4ePJisThpYWNDF1MfGCpYarUjhatJ0sVluOx3682V7t+wf6fs2f2T/zFvL2eX/wgH/U/wAPlbfsn/T\
Dy/sP/Lr9l/4kWdeXW7SJo/te/Om2yeV/aPmZ22vgRfL8j/hMJd2PsmNn2V8fYtv2eP7N5eiQWUOvt/\
Z+fDujtv8A7Izia9l3+Z/wr3OP+LPS+du+2SY/13mfax/x8/bD/bebeJ4gXR5pBoGjKRpts/mG8vYwC\
1r4CYv9o/4VbFtBN253/al3faw3nyfazJrP3cPij6o/nU0tPvd9lq3/ABMN+/WPHA/5C/m79+v/ABSG\
M/8ACwp/N3fa+mZt/wBtxi4+1bdc2L293fb/APT9+/8Atb/mLeZv8z/hP/8Aqf5vN3fa/wDpv5n27/l\
6+1f8T3k7W31qO01UQaBpZRdU8ZsTL9rs2SVda+KTTIET4QxiOOOe0Kq+YDssvMK2Zttuh6l7Dr6/2h\
jw7o67P7Xxma9i2eX/AMLCxn/iz0Xk7fscef8AU+X9kP8Ax7fYx/YiaabWmnmgDXL3OteE2/tDOPHdt\
Nv/ALX3Y2H4kz+f5n/Cwn27ftHmeb5qbPtPnfb7fz/7Q1PYsr3b9g/0/Zs/sn/mLeXs8v8A4QD/AKn+\
Hytv2T/ph5f2H/l1+y/8SLk9Zt9a/tnwwsmgaXG3/CcWkUEafayszyXHxGt2tpVb4QxeWhtoJAIxBOZ\
HtBanT5liNnpWpZQ6+39n58O6O2/+yM4mvZd/mf8ACvc4/wCLPS+du+2SY/13mfax/wAfP2w/22Wem2\
vmv6XzA2LK92/YP9P2bP7J/wCYt5ezy/8AhAP+p/h8rb9k/wCmHl/Yf+XX7L/xIvIdYuN3w/0Ifad++\
7+B4x9u8zf5P9jwY2/8JRN5vl7/AC8bJvK3+TjT9/8AZs/o1lDr7f2fnw7o7b/7Izia9l3+Z/wr3OP+\
LPS+du+2SY/13mfax/x8/bD/AG35Jrq63H4E0fyNF0poI7/4I+RLNdXdpKYpv7JnR5Y0+HSi0kl8tJC\
omQSbTMJNR8salD6GVL/hRwL/AOn1Hqv+fsP6vsjwOK/+SX4k/wCxfjP/AFHqHud7e7vt/wDp+/f/AG\
t/zFvM3+Z/wn//AFP83m7vtf8A038z7d/y9fav+J7jzXu7X/EQ/tDfu0eE4/tfzN/m3vxh5x/wsKbzN\
/2vrtm8z7b1vPtONbL2HX1/tDHh3R12f2vjM17Fs8v/AIWFjP8AxZ6Lydv2OPP+p8v7If8Aj2+xj+xM\
u4t9aTWtfZdA0tZ10va6N9rhiiihu/i8bd0uB8IYiJN9rIHQrALcWCsrW5tyNC4EtJendd1/X/DM98+\
EPjh+xh+zf+0/+1PB4g+NXhrxTrupx/ss2XwymvPDnxx+NHwsj1DwB4g8c6KviTwZrUfwt+OXh2HXdA\
u47q5F5aXs08bLaQ+dbaeLC3k0gr6W02PXX/aOVDoWku//AApLwm/ki5vJl23HjvwqGl8v/hWE5LSG4\
YBvshFx54BudS8/ytRKXE+QZJiKuVVauTYSpVqYKhKUp4ejzSlK8pSblC8nKTcnJ3bbbbe5+gw414x4\
aw+XYPhzizM8gwdbC0Kk6WCx+KwtOdRpxdSVOhVpxlNxioubTk0kr2SPoW9stv2//QNmz+1v+YT5ezy\
/+E//AOpAh8rb9k/6YeX9h/5dfsv/ABIsfxdZbdA8Vj+z9u3R/FIx/ZGzb5dl8RuMf8K9j8vb9k6bYt\
n2LpbfZcaHnXXibw5/pn+n+FU/5CX3PE/w7fy/+Ry+59l01fM2Z+Xydm/+z4Ps3l/aNH+yZXifxDoNx\
oniSCC58Myzz6V4ihhgg8S/DueR5ZbTxwkcMCW2ljz3DsojEIHmGxgFuE+06OLS4wldbPXuv8z8+O+t\
rLde3a/YN23xHqEOz+yd+3Z4g8JQ/Z/L/wCEAk2bftGzyfJi2favK/s+Dz/sGqFlZbvsH+gb9/8AZP8\
AzCfM3+Z/wgH/AFIE3m7vtf8A038z7d/y9fav+J7y0Hibw59ruP8AT/Crf8Ty9+RvE/w7VE/4nXhv/R\
lkn01ongX/AFayxqtkyXcskMKWcOow3Ba+JvDn+h/6f4Vf/kG/f8T/AA7TzP8AkTfv/atNby9+Pm87f\
s/tCf7T5n2fWPta5JeX3r/MDR8P2W691L/iX7vM1jQj/wAgjf5nmaB8IxnP/CvZfO3fa+ubnf8AbcZu\
vtW3W57O13aRDJ9k35025fzf7O8zO218dt5nn/8ACHy7sfZM7/tT4+xbvtEf2bzNE5LRfEOgxXeovJc\
+GQlxqukTQPL4l+HcS3cS6J8NIGmU3WlnCNPBNG5mMmxrm5W5Mn2XWBdT23ibw5/ZsX/Ez8Mv/oM/75\
vEfghJT/o/i/8AeGG5tGuVkGchWkM5NhCEdZLjSWtKcJWa0u+Xqu3r5r1voBv+ILLbe6b/AMS/b5esa\
6f+QRs8vy9A+Lgzn/hXsXk7fsnXNts+xYza/ZduibFzZbb20X7Bt3eI9Ph2f2Ts3b/EHi2H7P5f/CAR\
7932fZ5Pky7/ALL5X9nz+R9g0vgda8Q6DLd6c8dz4ZKW+q6vNO8XiX4dyraRNonxLgWZja6WMos88Ma\
GEx72trZbYx/atHFrqz+JvDn2u3/0/wAKr/xPLL5F8T/Dtkf/AInXiT/Rmkg01Ykgb/VtLIrWSpaRST\
QvZzadDbz7OWmm/mtfTXX/AD0A6myst32D/QN+/wDsn/mE+Zv8z/hAP+pAm83d9r/6b+Z9u/5evtX/A\
BPcfwjZbtA8KD+z927R/Cwx/ZG/d5ll8OeMf8K9k8zd9r6bZd/23pc/asa5nWvibw5/of8Ap/hV/wDk\
G/f8T/DtPM/5E37/ANq01vL34+bzt+z+0J/tPmfZ9Y+15XhjxDoNvonhuCe58MxTwaV4dhmgn8S/DuC\
RJYrTwOkkM6XOlnyHLqwkEwPlm+nFwH+zawLs9nLe2nqrfffr07gdbFa5jvj9kzs03Snz/Z27Z5ngjW\
LrzM/8Ie3l7vL87fuh3+V9p+0XPl/2zafiD+3/APBv9ozWP2svH3iP4dfsW/Fv9pn4YfEL9nb4QfD3x\
Jf/AAv+I37MnwqbR4NF8M/8Fg/hN8RNEn1H456/4fvtL8Rw6J+194F1fTLiz0LUdOaDwvqcU9xp15p9\
raaf+zEfibw5su/+Jn4ZP+g6fyfEfggFP+KT1MeYgktC0kj/AOvZYis6TQpBcPJqr211HBJ4h0Ea3rk\
7XPhmKCXSoIY518S/Dt4zLDd/E95oYXtdLTznhS4gOISu4W9sbYRfatHNrw5plcM2wk8JUqyoxbpzjO\
n7JyhOnKE4TSqwq0nyzjF8tSnOnKyjOMotxfNisJQxtFUMTT9rR9pSqOL2k6NWFaCfeLnTjzLrG66n8\
mNr/wAE4fiToljb6VpH/BKP/gqFoWlaNF8QYdM0mx/4KYfsM6fpWkRfETwxq3gr4iRxabZeJ4YIF1fw\
b4fsNI1wJHH/AGlpnhG4sLvNrHFFp/6Afst6r+2N+x78Pte+Gvw9/wCCQH7aPivQtb+KuieLJLz4qft\
qfsC/ELxPpt5oml/BH4ZeHfA1nq83jGKSLQtO8MfDHwZo9laSxvFpy6nFbW8NvpuNNm/eO68TeHP9M/\
0/wqn/ACEvueJ/h2/l/wDI5fc+y6avmbM/L5Ozf/Z8H2by/tGj/ZMrUfEOgzB0hufDNy48YafM0K+Jf\
h3iOK38a+C7idA0+lvE1pDBFJmaNFsvJnmmhijs4NRjn+EynwwweS4mOKyriDH4TEJcqlGGUyaTSjZK\
WWSSfKlFNK/L7q0dj9O4n8WvEfjTAvLeLOMcx4hy+VRVZUcVjcVWpyqRc5KU4yrNTtOcppSuvaP2lud\
KS/OW1/bM/wCChn+ibf8Agin+0HP/AMg7bs/ap/YDf7R/yJ+zy/M+Icnmedi22bvN3/8ACSW/mef9ou\
v7To3P7Zf/AAUK/s6Td/wRc+P0CfYoc3r/ALV37BCQovkeE8XTTR/E6OQRsBbuGE6uR4hgJldp7p9S/\
T218TeHP9D/ANP8Kv8A8g37/if4dp5n/Im/f+1aa3l78fN52/Z/aE/2nzPs+sfa6Nz4m8Of2bL/AMTP\
wyn+gwfvl8R+CHlH+j+EP3ghtrRblpDjJVZBODfzB3aS31Zrv6SPD2bKUX/rrmS1X/LvJf8A50nwHtY\
f9A8Pvqf/ACw/Myz/AGyP+Cg8drqCxf8ABFj9oPYdS8VSSPJ+1J+wJa/ZZpdY8fS3cMiL8QototbiS9\
jZ08sEeF7iSIwiG0OmaV1+2Z/wUM/0vd/wRT/aDg/5CO7f+1T+wGn2f/kcN/meX8Q4/L8nNzv2+Vs/4\
Ru48vyPs9r/AGZ+jVj4h0GG01JJrnwzau2q+LplQ+Jfh2WWK41v4hzwTRi10uPzUMEsckRhC+atpbtb\
lPtOjm01brxN4c/0z/T/AAqn/IS+54n+Hb+X/wAjl9z7Lpq+Zsz8vk7N/wDZ8H2by/tGj/ZF/q9m+z4\
0zNPzp5Kn939kh7WH/QPD76n/AMsPy+1X9sj/AIKDvqnh5pv+CLH7QdtLF4sgktbRv2pP2BGe+uyfG8\
Y0ZfL+ISpFcSJLexKrxtA8vh+W3a1ljW3tLLStf2zP+Chn+ibf+CKf7Qc//IO27P2qf2A3+0f8ifs8v\
zPiHJ5nnYttm7zd/wDwklv5nn/aLr+0/wBGtX8Q6DJq3hp47nwyyW/jCCafyvEvw7kiiiI8eQBJ5YNL\
EUNo888NuZpF+xKIoHmiezn06CDVtfE3hz/Q/wDT/Cr/APIN+/4n+HaeZ/yJv3/tWmt5e/Hzedv2f2h\
P9p8z7PrH2s/1ezfT/jNMz1/6d5Lr6f8ACTr/AJ6B7WH/AEDw++p/8sPzQtf2zP8AgoZ/om3/AIIp/t\
Bz/wDIO27P2qf2A3+0f8ifs8vzPiHJ5nnYttm7zd//AAklv5nn/aLr+0+Auf2sP+ChuseELPTNK/4I4\
fHqFra18A6lZ6pP+09+wlNAkfh3S4datbq60+H4vWssdte2umtebVuLdvs8Mk073U8a3kX63Wvibw5/\
of8Ap/hV/wDkG/f8T/DtPM/5E37/ANq01vL34+bzt+z+0J/tPmfZ9Y+1854f8QaDb6DZQT3vhyGeHw5\
4ehmhm8Q+CIpbWWLwRfRyAxyWIJn3hpZEiEc8c9utvcM+qvbXMWtDI86w9WFelxtmUalGUZRfsckklK\
MlKN1LKHF6q9mrO1mmro5cdh8HmOCxmXYzCRqYTH0qlGrFVK9OUqdWDhNKdOrCpBuMmlOEozi3eMlJJ\
r8vp/2vf+CqP+k+Z/wR8+J0P/H75ufjX+w/D5OP+El+0Z2ftGL5HlbdWzt2eV/Yj7PL+w2/2PNb9rr/\
AIKljWNXlf8A4JBfE+OdtNt47q3Pxm/YhgFpDFdePmMxuE/aLQKQ768pRSht/wDhHGZRF9ltvsf67XX\
ibw5/pn+n+FU/5CX3PE/w7fy/+Ry+59l01fM2Z+Xydm/+z4Ps3l/aNH+yZUniHQRreuTtc+GYoJdKgh\
jnXxL8O3jMsN38T3mhhe10tPOeFLiA4hK7hb2xthF9q0c2vSsuz7X/AIzHGf8AhDw53X/Uk/rTueV/q\
/lf/UZ/4ds4/wDngfj5bftG/wDBVAfESPx9F/wSM+KUzS+C9L8HxaT/AMLm/YlnilEOuaDrVvqKTy/t\
MvG8kxudJiKC3LzjWIjNNOt26XJX7MWvibw5/of+n+FX/wCQb9/xP8O08z/kTfv/AGrTW8vfj5vO37P\
7Qn+0+Z9n1j7WVeKw/E2J9h7TjLFVvYQjTjfAcNe7CHwxX/CGr2vu7va72OmplWBrey9rPGT9hCNON8\
0zbSEW3GP+/a2u9Xdvq3ZHU3t7u+3/AOn79/8Aa3/MW8zf5n/Cf/8AU/zebu+1/wDTfzPt3/L19q/4n\
uP4uvd2geKz/aG7do/ik5/tffu8yy+I3Of+FhSeZu+19d0u/wC29bn7VnXCivTjuvU9A2La923t232/\
bu8R6hNv/tbZu3+IPCU32jzP+E/j37vs+/zvOl3/AGXzf7Qn8j7fpZZXu37B/p+zZ/ZP/MW8vZ5f/CA\
f9T/D5W37J/0w8v7D/wAuv2X/AIkRRSAx/D97tvdS/wCJht8vWNCH/IX2eX5egfCM4x/wsKLydv2Tpi\
22fYs4tfsu7RJ7O626RDH9r2Y025Tyv7R8vG618dr5fkf8JhFtz9rxs+ypn7bt+zyfafL1soq38L9Y/\
kwIPEF7uvdN/wCJhu8zWNdH/IX3+Z5mgfFw4x/wsKXzt32vpi53/bc4uvtW7W9i5vd17aN9v3bfEenz\
b/7W37dniDxbN9o8z/hP5Nm37Rv87zotn2rzf7Qg8/7fqhRUAFle7fsH+n7Nn9k/8xby9nl/8IB/1P8\
AD5W37J/0w8v7D/y6/Zf+JFj+Eb3boHhQ/wBobduj+Fjn+19m3y7L4c85/wCFhR+Xt+ydd0Wz7F1tvs\
udDKKAJ4rrEd8PteN+m6UmP7R27/L8Eaxa+Xj/AITBfM2+Z5OzbNs837N9ntvM/sa7gmvd2v8AiIf2h\
v3aPCcf2v5m/wA29+MPOP8AhYU3mb/tfXbN5n23refaca2UVct3/hj+SA2L293fb/8AT9+/+1v+Yt5m\
/wAz/hP/APqf5vN3fa/+m/mfbv8Al6+1f8T3H1O92mR/7Q2bvHemzb/7X8vd5nxA+H8vn+b/AMLCh8z\
d9n3+b58u/wCzeb9vufI+26YUVMd16gbFle7fsH+n7Nn9k/8AMW8vZ5f/AAgH/U/w+Vt+yf8ATDy/sP\
8Ay6/Zf+JFnXl1u0iaP7Xvzptsnlf2j5mdtr4EXy/I/wCEwl3Y+yY2fZXx9i2/Z4/s3l6IUU4fHH1X5\
gQafe77LVv+Jhv36x44H/IX83fv1/4pDGf+FhT+bu+19Mzb/tuMXH2rbrmxe3u77f8A6fv3/wBrf8xb\
zN/mf8J//wBT/N5u77X/ANN/M+3f8vX2r/ielFSBj65e51rwm39oZx47tpt/9r7sbD8SZ/P8z/hYT7d\
v2jzPN81Nn2nzvt9v5/8AaGp7Fle7fsH+n7Nn9k/8xby9nl/8IB/1P8Plbfsn/TDy/sP/AC6/Zf8AiR\
FFABZXu37B/p+zZ/ZP/MW8vZ5f/CAf9T/D5W37J/0w8v7D/wAuv2X/AIkXLeGbr/inLD/TPv8AhXwun\
/IS/wBZs+HepWuz/kcv323zfJ2/6Rs837N5Fv5n9j3ZRVR2n6fqgOpvb3d9v/0/fv8A7W/5i3mb/M/4\
T/8A6n+bzd32v/pv5n27/l6+1f8AE9x5r3dr/iIf2hv3aPCcf2v5m/zb34w84/4WFN5m/wC19ds3mfb\
et59pxrZRSW0vT9UBsWV7t+wf6fs2f2T/AMxby9nl/wDCAf8AU/w+Vt+yf9MPL+w/8uv2X/iRFFFc1f\
7Hz/QqO/3fmj//2Q=='
	$end 'DesignInfo'
$end 'ProjectPreview'
